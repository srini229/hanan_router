MACRO CELL
  UNITS
    DATABASE MICRONS UNITS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN CELL 0 0 ;
  SIZE 60 BY 60 ;
  PIN P
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 32 32 ;
    END
  END P
END CELL
END LIBRARY
