MACRO bias_mos
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias_mos 0 0 ;
  SIZE 2810 BY 3610 ;
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 680 915 860 2695 ;
      LAYER M3 ;
        RECT 0 915 720 2695 ;
    END
  END G
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M2 ;
        RECT 2310 935 2810 2675 ;
    END
  END D
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 955 3180 1975 3390 ;
    END
  END B
  OBS
    LAYER M2 ;
      RECT 2310 935 2810 2675 ;
    LAYER M2 ;
      RECT 1950 935 2730 1115 ;
    LAYER M2 ;
      RECT 1950 1455 2730 1635 ;
    LAYER M2 ;
      RECT 1950 1975 2730 2155 ;
    LAYER M2 ;
      RECT 1950 2495 2730 2675 ;
    LAYER M2 ;
      RECT 975 2755 1955 2935 ;
    LAYER M2 ;
      RECT 975 2235 1955 2415 ;
    LAYER M2 ;
      RECT 975 1715 1955 1895 ;
    LAYER M2 ;
      RECT 975 1195 1955 1375 ;
    LAYER M2 ;
      RECT 975 675 1955 855 ;
    LAYER M2 ;
      RECT 680 915 860 2695 ;
    LAYER M2 ;
      RECT 1170 225 1760 425 ;
    LAYER M2 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M2 ;
      RECT 975 675 1955 855 ;
    LAYER M2 ;
      RECT 975 2495 1955 2675 ;
    LAYER M2 ;
      RECT 975 2235 1955 2415 ;
    LAYER M2 ;
      RECT 975 1975 1955 2155 ;
    LAYER M2 ;
      RECT 975 1715 1955 1895 ;
    LAYER M2 ;
      RECT 975 1455 1955 1635 ;
    LAYER M2 ;
      RECT 975 1195 1955 1375 ;
    LAYER M2 ;
      RECT 975 935 1955 1115 ;
    LAYER M2 ;
      RECT 975 2755 1955 2935 ;
    LAYER M2 ;
      RECT 680 915 860 2695 ;
    LAYER M2 ;
      RECT 1170 225 1760 425 ;
    LAYER M2 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M3 ;
      RECT 0 915 720 2695 ;
    LAYER M3 ;
      RECT 975 2755 1955 2935 ;
    LAYER M3 ;
      RECT 975 2235 1955 2415 ;
    LAYER M3 ;
      RECT 975 1715 1955 1895 ;
    LAYER M3 ;
      RECT 975 1195 1955 1375 ;
    LAYER M3 ;
      RECT 975 675 1955 855 ;
    LAYER M3 ;
      RECT 680 915 860 2695 ;
    LAYER M3 ;
      RECT 1170 225 1760 425 ;
    LAYER M3 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M3 ;
      RECT 1175 2755 1755 2935 ;
    LAYER M3 ;
      RECT 1175 2235 1755 2415 ;
    LAYER M3 ;
      RECT 1175 1715 1755 1895 ;
    LAYER M3 ;
      RECT 1175 1195 1755 1375 ;
    LAYER M3 ;
      RECT 1175 675 1755 855 ;
    LAYER M3 ;
      RECT 1170 225 1760 425 ;
    LAYER M3 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M4 ;
      RECT 1175 215 1755 3395 ;
    LAYER M4 ;
      RECT 1175 2755 1755 2935 ;
    LAYER M4 ;
      RECT 1175 2235 1755 2415 ;
    LAYER M4 ;
      RECT 1175 1715 1755 1895 ;
    LAYER M4 ;
      RECT 1175 1195 1755 1375 ;
    LAYER M4 ;
      RECT 1175 675 1755 855 ;
    LAYER M4 ;
      RECT 1170 225 1760 425 ;
    LAYER M4 ;
      RECT 1170 3185 1760 3385 ;
    LAYER PO ;
      RECT 675 865 865 2745 ;
    LAYER PO ;
      RECT 1965 2685 2105 2745 ;
    LAYER PO ;
      RECT 865 2685 965 2745 ;
    LAYER PO ;
      RECT 1965 2425 2105 2485 ;
    LAYER PO ;
      RECT 865 2425 965 2485 ;
    LAYER PO ;
      RECT 1965 2165 2105 2225 ;
    LAYER PO ;
      RECT 865 2165 965 2225 ;
    LAYER PO ;
      RECT 1965 1905 2105 1965 ;
    LAYER PO ;
      RECT 865 1905 965 1965 ;
    LAYER PO ;
      RECT 1965 1645 2105 1705 ;
    LAYER PO ;
      RECT 865 1645 965 1705 ;
    LAYER PO ;
      RECT 1965 1385 2105 1445 ;
    LAYER PO ;
      RECT 865 1385 965 1445 ;
    LAYER PO ;
      RECT 1965 1125 2105 1185 ;
    LAYER PO ;
      RECT 865 1125 965 1185 ;
    LAYER PO ;
      RECT 1965 865 2105 925 ;
    LAYER PO ;
      RECT 865 865 965 925 ;
    LAYER PO ;
      RECT 965 865 1965 925 ;
    LAYER PO ;
      RECT 965 1125 1965 1185 ;
    LAYER PO ;
      RECT 965 1385 1965 1445 ;
    LAYER PO ;
      RECT 965 1645 1965 1705 ;
    LAYER PO ;
      RECT 965 1905 1965 1965 ;
    LAYER PO ;
      RECT 965 2165 1965 2225 ;
    LAYER PO ;
      RECT 965 2425 1965 2485 ;
    LAYER PO ;
      RECT 965 2685 1965 2745 ;
    LAYER M1 ;
      RECT 955 2540 1975 2630 ;
    LAYER M1 ;
      RECT 955 2280 1975 2370 ;
    LAYER M1 ;
      RECT 955 2020 1975 2110 ;
    LAYER M1 ;
      RECT 955 1760 1975 1850 ;
    LAYER M1 ;
      RECT 955 1500 1975 1590 ;
    LAYER M1 ;
      RECT 955 1240 1975 1330 ;
    LAYER M1 ;
      RECT 955 980 1975 1070 ;
    LAYER M1 ;
      RECT 955 720 1975 810 ;
    LAYER M1 ;
      RECT 955 2800 1975 2890 ;
    LAYER M1 ;
      RECT 975 675 1955 855 ;
    LAYER M1 ;
      RECT 975 2495 1955 2675 ;
    LAYER M1 ;
      RECT 975 2235 1955 2415 ;
    LAYER M1 ;
      RECT 975 1975 1955 2155 ;
    LAYER M1 ;
      RECT 975 1715 1955 1895 ;
    LAYER M1 ;
      RECT 975 1455 1955 1635 ;
    LAYER M1 ;
      RECT 975 1195 1955 1375 ;
    LAYER M1 ;
      RECT 975 935 1955 1115 ;
    LAYER M1 ;
      RECT 975 2755 1955 2935 ;
    LAYER M1 ;
      RECT 680 915 860 2695 ;
    LAYER M1 ;
      RECT 1170 225 1760 425 ;
    LAYER M1 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M1 ;
      RECT 1975 220 2405 430 ;
    LAYER M1 ;
      RECT 1975 3180 2405 3390 ;
    LAYER M1 ;
      RECT 525 3180 955 3390 ;
    LAYER M1 ;
      RECT 525 220 955 430 ;
    LAYER M1 ;
      RECT 2405 220 2625 3390 ;
    LAYER M1 ;
      RECT 305 220 525 3390 ;
    LAYER M1 ;
      RECT 725 865 815 2745 ;
    LAYER M1 ;
      RECT 955 220 1975 430 ;
    LAYER M1 ;
      RECT 955 3180 1975 3390 ;
  END
END bias_mos
MACRO bias
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 0 50000 60000 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END bias
MACRO cas_mos
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN cas_mos 0 0 ;
  SIZE 9230 BY 8435 ;
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 3965 910 4615 ;
    END
  END GND
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 8318 2645 9230 4245 ;
    END
  END G2
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4615 8065 5655 ;
    END
  END SS
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 8065 2000 ;
    END
  END DD
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 6435 7865 8435 ;
    END
  END GG
  OBS
    LAYER M4 ;
      RECT 6485 3915 6665 4615 ;
    LAYER M4 ;
      RECT 5925 3915 6105 4615 ;
    LAYER M4 ;
      RECT 7045 3915 7225 4615 ;
    LAYER M4 ;
      RECT 7605 3915 7785 4615 ;
    LAYER M4 ;
      RECT 4245 3915 4425 4615 ;
    LAYER M4 ;
      RECT 3685 3915 3865 4615 ;
    LAYER M4 ;
      RECT 4805 3915 4985 4615 ;
    LAYER M4 ;
      RECT 5365 3915 5545 4615 ;
    LAYER M4 ;
      RECT 2565 3915 2745 4615 ;
    LAYER M4 ;
      RECT 3125 3915 3305 4615 ;
    LAYER M4 ;
      RECT 2005 3915 2185 4615 ;
    LAYER M4 ;
      RECT 1445 3915 1625 4615 ;
    LAYER M4 ;
      RECT 1365 5935 7865 6115 ;
    LAYER M4 ;
      RECT 1365 6115 7865 6295 ;
    LAYER M4 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M4 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M4 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M4 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M4 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M4 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M4 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M4 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M4 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M4 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M4 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M4 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M4 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M4 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M4 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M4 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M4 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M4 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M4 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M4 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M4 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M4 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M4 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M4 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M4 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M4 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M4 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M4 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M4 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M4 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M4 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M4 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M4 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M4 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M4 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M4 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M4 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M4 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M4 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M4 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M4 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M4 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M4 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M4 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M4 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M4 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M4 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M4 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M4 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M4 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M4 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M4 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M4 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M4 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M4 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M4 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M4 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M4 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M4 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M4 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M4 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M4 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M4 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M4 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M4 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M4 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M4 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M4 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M4 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M4 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M4 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M4 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M4 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M4 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M4 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M4 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M4 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M4 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M4 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M4 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M4 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M4 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M4 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M4 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M4 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M4 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M4 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M4 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M4 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M4 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M4 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M4 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M4 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M4 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M4 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M4 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M4 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M4 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M4 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M4 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M3 ;
      RECT 7855 2645 8545 2825 ;
    LAYER M3 ;
      RECT 7855 4065 8545 4245 ;
    LAYER M3 ;
      RECT 8318 2645 9230 4245 ;
    LAYER M3 ;
      RECT 1365 5755 7865 5935 ;
    LAYER M3 ;
      RECT 1365 2645 7865 2825 ;
    LAYER M3 ;
      RECT 1365 4065 7865 4245 ;
    LAYER M3 ;
      RECT 1365 5935 7865 6115 ;
    LAYER M3 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M3 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M3 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M3 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M3 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M3 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M3 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M3 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M3 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M3 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M3 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M3 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M3 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M3 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M3 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M3 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M3 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M3 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M3 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M3 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M3 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M3 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M3 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M3 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M3 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M3 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M3 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M3 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M3 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M3 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M3 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M3 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M3 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M3 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M3 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M3 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M3 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M3 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M3 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M3 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M3 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M3 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M3 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M3 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M3 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M3 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M3 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M3 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M3 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M3 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M3 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M3 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M3 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M3 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M3 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M3 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M3 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M3 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M3 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M3 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M3 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M3 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M3 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M3 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M3 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M3 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M3 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M3 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M3 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M3 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M3 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M3 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M3 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M3 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M3 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M3 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M3 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M3 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M3 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M3 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M3 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M3 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M3 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M3 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M3 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M3 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M3 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M3 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M3 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M3 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M3 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M3 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M3 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M3 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M3 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M3 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M3 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M3 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M3 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M3 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M5 ;
      RECT 7885 1765 8065 2925 ;
    LAYER M5 ;
      RECT 5645 1765 5825 2925 ;
    LAYER M5 ;
      RECT 6205 1765 6385 2925 ;
    LAYER M5 ;
      RECT 6765 1765 6945 2925 ;
    LAYER M5 ;
      RECT 7325 1765 7505 2925 ;
    LAYER M5 ;
      RECT 3405 1765 3585 2925 ;
    LAYER M5 ;
      RECT 3965 1765 4145 2925 ;
    LAYER M5 ;
      RECT 4525 1765 4705 2925 ;
    LAYER M5 ;
      RECT 5085 1765 5265 2925 ;
    LAYER M5 ;
      RECT 2285 1765 2465 2925 ;
    LAYER M5 ;
      RECT 2845 1765 3025 2925 ;
    LAYER M5 ;
      RECT 1725 1765 1905 2925 ;
    LAYER M5 ;
      RECT 1165 1765 1345 2925 ;
    LAYER M5 ;
      RECT 5925 3915 6105 4615 ;
    LAYER M5 ;
      RECT 6485 3915 6665 4615 ;
    LAYER M5 ;
      RECT 7045 3915 7225 4615 ;
    LAYER M5 ;
      RECT 7605 3915 7785 4615 ;
    LAYER M5 ;
      RECT 3685 3915 3865 4615 ;
    LAYER M5 ;
      RECT 4245 3915 4425 4615 ;
    LAYER M5 ;
      RECT 4805 3915 4985 4615 ;
    LAYER M5 ;
      RECT 5365 3915 5545 4615 ;
    LAYER M5 ;
      RECT 2565 3915 2745 4615 ;
    LAYER M5 ;
      RECT 3125 3915 3305 4615 ;
    LAYER M5 ;
      RECT 2005 3915 2185 4615 ;
    LAYER M5 ;
      RECT 1445 3915 1625 4615 ;
    LAYER M5 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M5 ;
      RECT 1365 6295 7865 6475 ;
    LAYER M5 ;
      RECT 1365 6115 7865 6295 ;
    LAYER M5 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M5 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M5 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M5 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M5 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M5 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M5 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M5 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M5 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M5 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M5 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M5 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M5 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M5 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M5 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M5 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M5 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M5 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M5 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M5 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M5 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M5 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M5 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M5 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M5 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M5 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M5 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M5 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M5 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M5 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M5 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M5 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M5 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M5 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M5 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M5 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M5 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M5 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M5 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M5 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M5 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M5 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M5 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M5 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M5 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M5 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M5 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M5 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M5 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M5 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M5 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M5 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M5 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M5 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M5 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M5 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M5 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M5 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M5 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M5 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M5 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M5 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M5 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M5 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M5 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M5 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M5 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M5 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M5 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M5 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M5 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M5 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M5 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M5 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M5 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M5 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M6 ;
      RECT 7885 1765 8065 2925 ;
    LAYER M6 ;
      RECT 5645 1765 5825 2925 ;
    LAYER M6 ;
      RECT 6205 1765 6385 2925 ;
    LAYER M6 ;
      RECT 6765 1765 6945 2925 ;
    LAYER M6 ;
      RECT 7325 1765 7505 2925 ;
    LAYER M6 ;
      RECT 3405 1765 3585 2925 ;
    LAYER M6 ;
      RECT 3965 1765 4145 2925 ;
    LAYER M6 ;
      RECT 4525 1765 4705 2925 ;
    LAYER M6 ;
      RECT 5085 1765 5265 2925 ;
    LAYER M6 ;
      RECT 2285 1765 2465 2925 ;
    LAYER M6 ;
      RECT 2845 1765 3025 2925 ;
    LAYER M6 ;
      RECT 1725 1765 1905 2925 ;
    LAYER M6 ;
      RECT 1165 1765 1345 2925 ;
    LAYER M6 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M6 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M6 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M6 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M6 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M6 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M6 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M6 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M6 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M6 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M6 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M6 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M6 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M6 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M6 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M6 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M6 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M6 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M6 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M6 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M6 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M6 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M6 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M6 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M6 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M6 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M6 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M6 ;
      RECT 1365 6295 7865 6475 ;
    LAYER M6 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M6 ;
      RECT 1365 6475 7865 6655 ;
    LAYER M6 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M6 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M6 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M6 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M6 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M6 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M6 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M6 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M6 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M6 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M6 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M6 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M6 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M6 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M6 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M6 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M6 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M6 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M6 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M6 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M6 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M6 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M6 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M6 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M6 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M6 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M7 ;
      RECT 7885 1765 8065 2925 ;
    LAYER M7 ;
      RECT 6765 1765 6945 2925 ;
    LAYER M7 ;
      RECT 6205 1765 6385 2925 ;
    LAYER M7 ;
      RECT 5645 1765 5825 2925 ;
    LAYER M7 ;
      RECT 7325 1765 7505 2925 ;
    LAYER M7 ;
      RECT 4525 1765 4705 2925 ;
    LAYER M7 ;
      RECT 3965 1765 4145 2925 ;
    LAYER M7 ;
      RECT 2285 1765 2465 2925 ;
    LAYER M7 ;
      RECT 3405 1765 3585 2925 ;
    LAYER M7 ;
      RECT 5085 1765 5265 2925 ;
    LAYER M7 ;
      RECT 2845 1765 3025 2925 ;
    LAYER M7 ;
      RECT 1725 1765 1905 2925 ;
    LAYER M7 ;
      RECT 1165 1765 1345 2925 ;
    LAYER M7 ;
      RECT 0 4615 8065 5655 ;
    LAYER M7 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M7 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M7 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M7 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M7 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M7 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M7 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M7 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M7 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M7 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M7 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M7 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M7 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M7 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M7 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M7 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M7 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M7 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M7 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M7 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M7 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M7 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M7 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M7 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M7 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M7 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M7 ;
      RECT 1365 6655 7865 7175 ;
    LAYER M7 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M7 ;
      RECT 1365 6475 7865 6655 ;
    LAYER M7 ;
      RECT 1165 1235 8065 1765 ;
    LAYER PO ;
      RECT 1365 5735 7865 5945 ;
    LAYER PO ;
      RECT 1365 4495 1425 4635 ;
    LAYER PO ;
      RECT 1365 5635 1425 5735 ;
    LAYER PO ;
      RECT 1645 4495 1705 4635 ;
    LAYER PO ;
      RECT 1645 5635 1705 5735 ;
    LAYER PO ;
      RECT 1925 4495 1985 4635 ;
    LAYER PO ;
      RECT 1925 5635 1985 5735 ;
    LAYER PO ;
      RECT 2205 4495 2265 4635 ;
    LAYER PO ;
      RECT 2205 5635 2265 5735 ;
    LAYER PO ;
      RECT 2485 4495 2545 4635 ;
    LAYER PO ;
      RECT 2485 5635 2545 5735 ;
    LAYER PO ;
      RECT 2765 4495 2825 4635 ;
    LAYER PO ;
      RECT 2765 5635 2825 5735 ;
    LAYER PO ;
      RECT 3045 4495 3105 4635 ;
    LAYER PO ;
      RECT 3045 5635 3105 5735 ;
    LAYER PO ;
      RECT 3325 4495 3385 4635 ;
    LAYER PO ;
      RECT 3325 5635 3385 5735 ;
    LAYER PO ;
      RECT 3605 4495 3665 4635 ;
    LAYER PO ;
      RECT 3605 5635 3665 5735 ;
    LAYER PO ;
      RECT 3885 4495 3945 4635 ;
    LAYER PO ;
      RECT 3885 5635 3945 5735 ;
    LAYER PO ;
      RECT 4165 4495 4225 4635 ;
    LAYER PO ;
      RECT 4165 5635 4225 5735 ;
    LAYER PO ;
      RECT 4445 4495 4505 4635 ;
    LAYER PO ;
      RECT 4445 5635 4505 5735 ;
    LAYER PO ;
      RECT 4725 4495 4785 4635 ;
    LAYER PO ;
      RECT 4725 5635 4785 5735 ;
    LAYER PO ;
      RECT 5005 4495 5065 4635 ;
    LAYER PO ;
      RECT 5005 5635 5065 5735 ;
    LAYER PO ;
      RECT 5285 4495 5345 4635 ;
    LAYER PO ;
      RECT 5285 5635 5345 5735 ;
    LAYER PO ;
      RECT 5565 4495 5625 4635 ;
    LAYER PO ;
      RECT 5565 5635 5625 5735 ;
    LAYER PO ;
      RECT 5845 4495 5905 4635 ;
    LAYER PO ;
      RECT 5845 5635 5905 5735 ;
    LAYER PO ;
      RECT 6125 4495 6185 4635 ;
    LAYER PO ;
      RECT 6125 5635 6185 5735 ;
    LAYER PO ;
      RECT 6405 4495 6465 4635 ;
    LAYER PO ;
      RECT 6405 5635 6465 5735 ;
    LAYER PO ;
      RECT 6685 4495 6745 4635 ;
    LAYER PO ;
      RECT 6685 5635 6745 5735 ;
    LAYER PO ;
      RECT 6965 4495 7025 4635 ;
    LAYER PO ;
      RECT 6965 5635 7025 5735 ;
    LAYER PO ;
      RECT 7245 4495 7305 4635 ;
    LAYER PO ;
      RECT 7245 5635 7305 5735 ;
    LAYER PO ;
      RECT 7525 4495 7585 4635 ;
    LAYER PO ;
      RECT 7525 5635 7585 5735 ;
    LAYER PO ;
      RECT 7805 4495 7865 4635 ;
    LAYER PO ;
      RECT 7805 5635 7865 5735 ;
    LAYER PO ;
      RECT 7805 4635 7865 5635 ;
    LAYER PO ;
      RECT 7525 4635 7585 5635 ;
    LAYER PO ;
      RECT 7245 4635 7305 5635 ;
    LAYER PO ;
      RECT 6965 4635 7025 5635 ;
    LAYER PO ;
      RECT 6685 4635 6745 5635 ;
    LAYER PO ;
      RECT 6405 4635 6465 5635 ;
    LAYER PO ;
      RECT 6125 4635 6185 5635 ;
    LAYER PO ;
      RECT 5845 4635 5905 5635 ;
    LAYER PO ;
      RECT 5565 4635 5625 5635 ;
    LAYER PO ;
      RECT 5285 4635 5345 5635 ;
    LAYER PO ;
      RECT 5005 4635 5065 5635 ;
    LAYER PO ;
      RECT 4725 4635 4785 5635 ;
    LAYER PO ;
      RECT 4445 4635 4505 5635 ;
    LAYER PO ;
      RECT 4165 4635 4225 5635 ;
    LAYER PO ;
      RECT 3885 4635 3945 5635 ;
    LAYER PO ;
      RECT 3605 4635 3665 5635 ;
    LAYER PO ;
      RECT 3325 4635 3385 5635 ;
    LAYER PO ;
      RECT 3045 4635 3105 5635 ;
    LAYER PO ;
      RECT 2765 4635 2825 5635 ;
    LAYER PO ;
      RECT 2485 4635 2545 5635 ;
    LAYER PO ;
      RECT 2205 4635 2265 5635 ;
    LAYER PO ;
      RECT 1925 4635 1985 5635 ;
    LAYER PO ;
      RECT 1645 4635 1705 5635 ;
    LAYER PO ;
      RECT 1365 4635 1425 5635 ;
    LAYER PO ;
      RECT 1365 2635 7865 2845 ;
    LAYER PO ;
      RECT 1365 4045 7865 4255 ;
    LAYER PO ;
      RECT 1365 2845 1425 2945 ;
    LAYER PO ;
      RECT 1365 3945 1425 4045 ;
    LAYER PO ;
      RECT 1645 2845 1705 2945 ;
    LAYER PO ;
      RECT 1645 3945 1705 4045 ;
    LAYER PO ;
      RECT 1925 2845 1985 2945 ;
    LAYER PO ;
      RECT 1925 3945 1985 4045 ;
    LAYER PO ;
      RECT 2205 2845 2265 2945 ;
    LAYER PO ;
      RECT 2205 3945 2265 4045 ;
    LAYER PO ;
      RECT 2485 2845 2545 2945 ;
    LAYER PO ;
      RECT 2485 3945 2545 4045 ;
    LAYER PO ;
      RECT 2765 2845 2825 2945 ;
    LAYER PO ;
      RECT 2765 3945 2825 4045 ;
    LAYER PO ;
      RECT 3045 2845 3105 2945 ;
    LAYER PO ;
      RECT 3045 3945 3105 4045 ;
    LAYER PO ;
      RECT 3325 2845 3385 2945 ;
    LAYER PO ;
      RECT 3325 3945 3385 4045 ;
    LAYER PO ;
      RECT 3605 2845 3665 2945 ;
    LAYER PO ;
      RECT 3605 3945 3665 4045 ;
    LAYER PO ;
      RECT 3885 2845 3945 2945 ;
    LAYER PO ;
      RECT 3885 3945 3945 4045 ;
    LAYER PO ;
      RECT 4165 2845 4225 2945 ;
    LAYER PO ;
      RECT 4165 3945 4225 4045 ;
    LAYER PO ;
      RECT 4445 2845 4505 2945 ;
    LAYER PO ;
      RECT 4445 3945 4505 4045 ;
    LAYER PO ;
      RECT 4725 2845 4785 2945 ;
    LAYER PO ;
      RECT 4725 3945 4785 4045 ;
    LAYER PO ;
      RECT 5005 2845 5065 2945 ;
    LAYER PO ;
      RECT 5005 3945 5065 4045 ;
    LAYER PO ;
      RECT 5285 2845 5345 2945 ;
    LAYER PO ;
      RECT 5285 3945 5345 4045 ;
    LAYER PO ;
      RECT 5565 2845 5625 2945 ;
    LAYER PO ;
      RECT 5565 3945 5625 4045 ;
    LAYER PO ;
      RECT 5845 2845 5905 2945 ;
    LAYER PO ;
      RECT 5845 3945 5905 4045 ;
    LAYER PO ;
      RECT 6125 2845 6185 2945 ;
    LAYER PO ;
      RECT 6125 3945 6185 4045 ;
    LAYER PO ;
      RECT 6405 2845 6465 2945 ;
    LAYER PO ;
      RECT 6405 3945 6465 4045 ;
    LAYER PO ;
      RECT 6685 2845 6745 2945 ;
    LAYER PO ;
      RECT 6685 3945 6745 4045 ;
    LAYER PO ;
      RECT 6965 2845 7025 2945 ;
    LAYER PO ;
      RECT 6965 3945 7025 4045 ;
    LAYER PO ;
      RECT 7245 2845 7305 2945 ;
    LAYER PO ;
      RECT 7245 3945 7305 4045 ;
    LAYER PO ;
      RECT 7525 2845 7585 2945 ;
    LAYER PO ;
      RECT 7525 3945 7585 4045 ;
    LAYER PO ;
      RECT 7805 2845 7865 2945 ;
    LAYER PO ;
      RECT 7805 3945 7865 4045 ;
    LAYER PO ;
      RECT 7805 2945 7865 3945 ;
    LAYER PO ;
      RECT 7525 2945 7585 3945 ;
    LAYER PO ;
      RECT 7245 2945 7305 3945 ;
    LAYER PO ;
      RECT 6965 2945 7025 3945 ;
    LAYER PO ;
      RECT 6685 2945 6745 3945 ;
    LAYER PO ;
      RECT 6405 2945 6465 3945 ;
    LAYER PO ;
      RECT 6125 2945 6185 3945 ;
    LAYER PO ;
      RECT 5845 2945 5905 3945 ;
    LAYER PO ;
      RECT 5565 2945 5625 3945 ;
    LAYER PO ;
      RECT 5285 2945 5345 3945 ;
    LAYER PO ;
      RECT 5005 2945 5065 3945 ;
    LAYER PO ;
      RECT 4725 2945 4785 3945 ;
    LAYER PO ;
      RECT 4445 2945 4505 3945 ;
    LAYER PO ;
      RECT 4165 2945 4225 3945 ;
    LAYER PO ;
      RECT 3885 2945 3945 3945 ;
    LAYER PO ;
      RECT 3605 2945 3665 3945 ;
    LAYER PO ;
      RECT 3325 2945 3385 3945 ;
    LAYER PO ;
      RECT 3045 2945 3105 3945 ;
    LAYER PO ;
      RECT 2765 2945 2825 3945 ;
    LAYER PO ;
      RECT 2485 2945 2545 3945 ;
    LAYER PO ;
      RECT 2205 2945 2265 3945 ;
    LAYER PO ;
      RECT 1925 2945 1985 3945 ;
    LAYER PO ;
      RECT 1645 2945 1705 3945 ;
    LAYER PO ;
      RECT 1365 2945 1425 3945 ;
    LAYER M1 ;
      RECT 1490 4615 1580 5655 ;
    LAYER M1 ;
      RECT 1770 4615 1860 5655 ;
    LAYER M1 ;
      RECT 2050 4615 2140 5655 ;
    LAYER M1 ;
      RECT 2330 4615 2420 5655 ;
    LAYER M1 ;
      RECT 2610 4615 2700 5655 ;
    LAYER M1 ;
      RECT 2890 4615 2980 5655 ;
    LAYER M1 ;
      RECT 3170 4615 3260 5655 ;
    LAYER M1 ;
      RECT 3450 4615 3540 5655 ;
    LAYER M1 ;
      RECT 3730 4615 3820 5655 ;
    LAYER M1 ;
      RECT 4010 4615 4100 5655 ;
    LAYER M1 ;
      RECT 4290 4615 4380 5655 ;
    LAYER M1 ;
      RECT 4570 4615 4660 5655 ;
    LAYER M1 ;
      RECT 4850 4615 4940 5655 ;
    LAYER M1 ;
      RECT 5130 4615 5220 5655 ;
    LAYER M1 ;
      RECT 5410 4615 5500 5655 ;
    LAYER M1 ;
      RECT 5690 4615 5780 5655 ;
    LAYER M1 ;
      RECT 5970 4615 6060 5655 ;
    LAYER M1 ;
      RECT 6250 4615 6340 5655 ;
    LAYER M1 ;
      RECT 6530 4615 6620 5655 ;
    LAYER M1 ;
      RECT 6810 4615 6900 5655 ;
    LAYER M1 ;
      RECT 7090 4615 7180 5655 ;
    LAYER M1 ;
      RECT 7370 4615 7460 5655 ;
    LAYER M1 ;
      RECT 7650 4615 7740 5655 ;
    LAYER M1 ;
      RECT 7930 4615 8020 5655 ;
    LAYER M1 ;
      RECT 1210 4615 1300 5655 ;
    LAYER M1 ;
      RECT 1490 2925 1580 3965 ;
    LAYER M1 ;
      RECT 1770 2925 1860 3965 ;
    LAYER M1 ;
      RECT 2050 2925 2140 3965 ;
    LAYER M1 ;
      RECT 2330 2925 2420 3965 ;
    LAYER M1 ;
      RECT 2610 2925 2700 3965 ;
    LAYER M1 ;
      RECT 2890 2925 2980 3965 ;
    LAYER M1 ;
      RECT 3170 2925 3260 3965 ;
    LAYER M1 ;
      RECT 3450 2925 3540 3965 ;
    LAYER M1 ;
      RECT 3730 2925 3820 3965 ;
    LAYER M1 ;
      RECT 4010 2925 4100 3965 ;
    LAYER M1 ;
      RECT 4290 2925 4380 3965 ;
    LAYER M1 ;
      RECT 4570 2925 4660 3965 ;
    LAYER M1 ;
      RECT 4850 2925 4940 3965 ;
    LAYER M1 ;
      RECT 5130 2925 5220 3965 ;
    LAYER M1 ;
      RECT 5410 2925 5500 3965 ;
    LAYER M1 ;
      RECT 5690 2925 5780 3965 ;
    LAYER M1 ;
      RECT 5970 2925 6060 3965 ;
    LAYER M1 ;
      RECT 6250 2925 6340 3965 ;
    LAYER M1 ;
      RECT 6530 2925 6620 3965 ;
    LAYER M1 ;
      RECT 6810 2925 6900 3965 ;
    LAYER M1 ;
      RECT 7090 2925 7180 3965 ;
    LAYER M1 ;
      RECT 7370 2925 7460 3965 ;
    LAYER M1 ;
      RECT 7650 2925 7740 3965 ;
    LAYER M1 ;
      RECT 7930 2925 8020 3965 ;
    LAYER M1 ;
      RECT 1210 2925 1300 3965 ;
    LAYER M1 ;
      RECT 1365 5755 7865 5935 ;
    LAYER M1 ;
      RECT 1365 2645 7865 2825 ;
    LAYER M1 ;
      RECT 1365 4065 7865 4245 ;
    LAYER M1 ;
      RECT 8320 3965 8530 4615 ;
    LAYER M1 ;
      RECT 700 3965 910 4615 ;
    LAYER M1 ;
      RECT 8320 2485 8530 2925 ;
    LAYER M1 ;
      RECT 700 2485 910 2925 ;
    LAYER M1 ;
      RECT 700 5655 910 6095 ;
    LAYER M1 ;
      RECT 8320 5655 8530 6095 ;
    LAYER M1 ;
      RECT 700 6095 8530 6315 ;
    LAYER M1 ;
      RECT 700 2265 8530 2485 ;
    LAYER M1 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M1 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M1 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M1 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M1 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M1 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M1 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M1 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M1 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M1 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M1 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M1 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M1 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M1 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M1 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M1 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M1 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M1 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M1 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M1 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M1 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M1 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M1 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M1 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M1 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M1 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M1 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M1 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M1 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M1 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M1 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M1 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M1 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M1 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M1 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M1 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M1 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M1 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M1 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M1 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M1 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M1 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M1 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M1 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M1 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M1 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M1 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M1 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M1 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M1 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M1 ;
      RECT 1365 5795 7865 5885 ;
    LAYER M1 ;
      RECT 8320 4615 8530 5655 ;
    LAYER M1 ;
      RECT 700 4615 910 5655 ;
    LAYER M1 ;
      RECT 1365 2695 7865 2785 ;
    LAYER M1 ;
      RECT 1365 4105 7865 4195 ;
    LAYER M1 ;
      RECT 8320 2925 8530 3965 ;
    LAYER M1 ;
      RECT 700 2925 910 3965 ;
    LAYER M2 ;
      RECT 1365 5755 7865 5935 ;
    LAYER M2 ;
      RECT 1365 2645 7865 2825 ;
    LAYER M2 ;
      RECT 1365 4065 7865 4245 ;
    LAYER M2 ;
      RECT 1365 5755 7865 5935 ;
    LAYER M2 ;
      RECT 1365 2645 7865 2825 ;
    LAYER M2 ;
      RECT 1365 4065 7865 4245 ;
    LAYER M2 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M2 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M2 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M2 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M2 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M2 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M2 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M2 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M2 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M2 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M2 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M2 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M2 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M2 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M2 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M2 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M2 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M2 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M2 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M2 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M2 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M2 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M2 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M2 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M2 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M2 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M2 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M2 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M2 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M2 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M2 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M2 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M2 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M2 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M2 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M2 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M2 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M2 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M2 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M2 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M2 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M2 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M2 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M2 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M2 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M2 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M2 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M2 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M2 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M2 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M2 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M2 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M2 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M2 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M2 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M2 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M2 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M2 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M2 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M2 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M2 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M2 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M2 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M2 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M2 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M2 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M2 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M2 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M2 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M2 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M2 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M2 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M2 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M2 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M2 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M2 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M2 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M2 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M2 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M2 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M2 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M2 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M2 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M2 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M2 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M2 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M2 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M2 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M2 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M2 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M2 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M2 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M2 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M2 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M2 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M2 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M2 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M2 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M2 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M2 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M8 ;
      RECT 1365 6655 7865 7175 ;
    LAYER M8 ;
      RECT 1365 7175 7865 7695 ;
    LAYER M8 ;
      RECT 1165 740 8065 1260 ;
    LAYER M8 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M9 ;
      RECT 1365 6435 7865 8435 ;
    LAYER M9 ;
      RECT 1165 0 8065 2000 ;
  END
END cas_mos
MACRO drain_ind_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind_x.25 0 0 ;
  SIZE 117445 BY 120070 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 85195 54285 117445 62785 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 23375 20750 83195 120070 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 106570 106570 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 64195 54285 93695 62785 ;
    LAYER M9 ;
      RECT 85195 54285 117445 62785 ;
    LAYER M9 ;
      RECT 23375 20750 83195 120070 ;
    LAYER M1 ;
      RECT 0 0 106570 106570 ;
  END
END drain_ind_x.25
MACRO gate_ind_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.1 0 0 ;
  SIZE 119600 BY 111600 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 85100 57425 119600 60425 ;
      LAYER M9 ;
        RECT 23500 25060 119600 86540 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 23500 25060 119600 86540 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 111600 111600 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 72600 57425 88100 60425 ;
    LAYER M9 ;
      RECT 85100 57425 119600 60425 ;
    LAYER M9 ;
      RECT 23500 25060 119600 86540 ;
    LAYER M1 ;
      RECT 0 0 111600 111600 ;
  END
END gate_ind_x.1
MACRO gnd0
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd0 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 0 50000 60000 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd0
MACRO gnd1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gnd1 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 0 50000 60000 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END gnd1
MACRO input
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN input 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 0 50000 60000 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END input
MACRO output
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN output 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 0 50000 60000 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END output
MACRO source_ind_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN source_ind_x.25 0 0 ;
  SIZE 134655 BY 137370 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 104280 64125 134655 71625 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 23965 21250 100905 137370 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 124870 124870 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 82530 64125 111780 71625 ;
    LAYER M9 ;
      RECT 104280 64125 134655 71625 ;
    LAYER M9 ;
      RECT 23965 21250 100905 137370 ;
    LAYER M1 ;
      RECT 0 0 124870 124870 ;
  END
END source_ind_x.25
MACRO vdd
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN vdd 0 0 ;
  SIZE 50000 BY 60000 ;
  PIN PAD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 0 50000 60000 ;
    END
  END PAD
  OBS
    LAYER M8 ;
      RECT 0 0 50000 60000 ;
    LAYER M8 ;
      RECT 1790 3190 48210 56810 ;
    LAYER M9 ;
      RECT 0 0 50000 60000 ;
    LAYER M9 ;
      RECT 1570 2970 48430 57030 ;
  END
END vdd
MACRO xc1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc1_1 0 0 ;
  SIZE 24100 BY 19100 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 11450 0 12650 19100 ;
      LAYER M5 ;
        RECT 2500 18670 21600 19100 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 11450 0 12650 19100 ;
      LAYER M5 ;
        RECT 2500 0 21600 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 8370 21600 10730 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 22440 0 24100 19100 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 11570 21600 19100 ;
    LAYER M8 ;
      RECT 2500 0 21600 7530 ;
    LAYER M8 ;
      RECT 21600 17440 24100 19100 ;
    LAYER M8 ;
      RECT 21600 0 24100 1660 ;
    LAYER M8 ;
      RECT 22440 0 24100 19100 ;
    LAYER M8 ;
      RECT 0 8370 21600 10730 ;
    LAYER M8 ;
      RECT 5000 10730 6740 16600 ;
    LAYER M8 ;
      RECT 5000 10730 6740 16600 ;
    LAYER M8 ;
      RECT 5000 2500 6740 8370 ;
    LAYER M8 ;
      RECT 8090 10730 9830 16600 ;
    LAYER M8 ;
      RECT 8090 10730 9830 16600 ;
    LAYER M8 ;
      RECT 8090 2500 9830 8370 ;
    LAYER M8 ;
      RECT 11180 10730 12920 16600 ;
    LAYER M8 ;
      RECT 11180 10730 12920 16600 ;
    LAYER M8 ;
      RECT 11180 2500 12920 8370 ;
    LAYER M8 ;
      RECT 14270 10730 16010 16600 ;
    LAYER M8 ;
      RECT 14270 10730 16010 16600 ;
    LAYER M8 ;
      RECT 14270 2500 16010 8370 ;
    LAYER M8 ;
      RECT 17360 10730 19100 16600 ;
    LAYER M8 ;
      RECT 17360 10730 19100 16600 ;
    LAYER M8 ;
      RECT 17360 2500 19100 8370 ;
    LAYER M5 ;
      RECT 11450 0 12650 19100 ;
    LAYER M5 ;
      RECT 2500 8950 21600 10150 ;
    LAYER M5 ;
      RECT 13250 11350 14450 19100 ;
    LAYER M5 ;
      RECT 13250 10750 21600 11950 ;
    LAYER M5 ;
      RECT 15050 13150 16250 19100 ;
    LAYER M5 ;
      RECT 15050 12550 21600 13750 ;
    LAYER M5 ;
      RECT 16850 14950 18050 19100 ;
    LAYER M5 ;
      RECT 16850 14350 21600 15550 ;
    LAYER M5 ;
      RECT 18650 16750 19850 19100 ;
    LAYER M5 ;
      RECT 18650 16150 21600 17350 ;
    LAYER M5 ;
      RECT 20450 18550 21600 19100 ;
    LAYER M5 ;
      RECT 20450 17950 21600 19100 ;
    LAYER M5 ;
      RECT 9650 11350 10850 19100 ;
    LAYER M5 ;
      RECT 2500 10750 10850 11950 ;
    LAYER M5 ;
      RECT 7850 13150 9050 19100 ;
    LAYER M5 ;
      RECT 2500 12550 9050 13750 ;
    LAYER M5 ;
      RECT 6050 14950 7250 19100 ;
    LAYER M5 ;
      RECT 2500 14350 7250 15550 ;
    LAYER M5 ;
      RECT 4250 16750 5450 19100 ;
    LAYER M5 ;
      RECT 2500 16150 5450 17350 ;
    LAYER M5 ;
      RECT 2500 18550 3650 19100 ;
    LAYER M5 ;
      RECT 2500 17950 3650 19100 ;
    LAYER M5 ;
      RECT 9650 0 10850 7750 ;
    LAYER M5 ;
      RECT 2500 7150 10850 8350 ;
    LAYER M5 ;
      RECT 7850 0 9050 5950 ;
    LAYER M5 ;
      RECT 2500 5350 9050 6550 ;
    LAYER M5 ;
      RECT 6050 0 7250 4150 ;
    LAYER M5 ;
      RECT 2500 3550 7250 4750 ;
    LAYER M5 ;
      RECT 4250 0 5450 2350 ;
    LAYER M5 ;
      RECT 2500 1750 5450 2950 ;
    LAYER M5 ;
      RECT 2500 0 3650 550 ;
    LAYER M5 ;
      RECT 2500 0 3650 1150 ;
    LAYER M5 ;
      RECT 13250 0 14450 7750 ;
    LAYER M5 ;
      RECT 13250 7150 21600 8350 ;
    LAYER M5 ;
      RECT 15050 0 16250 5950 ;
    LAYER M5 ;
      RECT 15050 5350 21600 6550 ;
    LAYER M5 ;
      RECT 16850 0 18050 4150 ;
    LAYER M5 ;
      RECT 16850 3550 21600 4750 ;
    LAYER M5 ;
      RECT 18650 0 19850 2350 ;
    LAYER M5 ;
      RECT 18650 1750 21600 2950 ;
    LAYER M5 ;
      RECT 20450 0 21600 550 ;
    LAYER M5 ;
      RECT 20450 0 21600 1150 ;
    LAYER M5 ;
      RECT 2500 18670 21600 19100 ;
    LAYER M5 ;
      RECT 2500 0 21600 430 ;
    LAYER M6 ;
      RECT 12350 10450 13550 19100 ;
    LAYER M6 ;
      RECT 12350 9850 21600 11050 ;
    LAYER M6 ;
      RECT 14150 12250 15350 19100 ;
    LAYER M6 ;
      RECT 14150 11650 21600 12850 ;
    LAYER M6 ;
      RECT 15950 14050 17150 19100 ;
    LAYER M6 ;
      RECT 15950 13450 21600 14650 ;
    LAYER M6 ;
      RECT 17750 15850 18950 19100 ;
    LAYER M6 ;
      RECT 17750 15250 21600 16450 ;
    LAYER M6 ;
      RECT 19550 17650 20750 19100 ;
    LAYER M6 ;
      RECT 19550 17050 21600 18250 ;
    LAYER M6 ;
      RECT 10550 10450 11750 19100 ;
    LAYER M6 ;
      RECT 2500 9850 11750 11050 ;
    LAYER M6 ;
      RECT 8750 12250 9950 19100 ;
    LAYER M6 ;
      RECT 2500 11650 9950 12850 ;
    LAYER M6 ;
      RECT 6950 14050 8150 19100 ;
    LAYER M6 ;
      RECT 2500 13450 8150 14650 ;
    LAYER M6 ;
      RECT 5150 15850 6350 19100 ;
    LAYER M6 ;
      RECT 2500 15250 6350 16450 ;
    LAYER M6 ;
      RECT 3350 17650 4550 19100 ;
    LAYER M6 ;
      RECT 2500 17050 4550 18250 ;
    LAYER M6 ;
      RECT 10550 0 11750 8650 ;
    LAYER M6 ;
      RECT 2500 8050 11750 9250 ;
    LAYER M6 ;
      RECT 8750 0 9950 6850 ;
    LAYER M6 ;
      RECT 2500 6250 9950 7450 ;
    LAYER M6 ;
      RECT 6950 0 8150 5050 ;
    LAYER M6 ;
      RECT 2500 4450 8150 5650 ;
    LAYER M6 ;
      RECT 5150 0 6350 3250 ;
    LAYER M6 ;
      RECT 2500 2650 6350 3850 ;
    LAYER M6 ;
      RECT 3350 0 4550 1450 ;
    LAYER M6 ;
      RECT 2500 850 4550 2050 ;
    LAYER M6 ;
      RECT 12350 0 13550 8650 ;
    LAYER M6 ;
      RECT 12350 8050 21600 9250 ;
    LAYER M6 ;
      RECT 14150 0 15350 6850 ;
    LAYER M6 ;
      RECT 14150 6250 21600 7450 ;
    LAYER M6 ;
      RECT 15950 0 17150 5050 ;
    LAYER M6 ;
      RECT 15950 4450 21600 5650 ;
    LAYER M6 ;
      RECT 17750 0 18950 3250 ;
    LAYER M6 ;
      RECT 17750 2650 21600 3850 ;
    LAYER M6 ;
      RECT 19550 0 20750 1450 ;
    LAYER M6 ;
      RECT 19550 850 21600 2050 ;
    LAYER M6 ;
      RECT 2500 18670 21600 19100 ;
    LAYER M6 ;
      RECT 2500 0 21600 430 ;
  END
END xc1_1
MACRO xc2_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc2_1 0 0 ;
  SIZE 13320 BY 8320 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6060 0 7260 8320 ;
      LAYER M5 ;
        RECT 2500 7890 10820 8320 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 6060 0 7260 8320 ;
      LAYER M5 ;
        RECT 2500 0 10820 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 2980 10820 5340 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 11660 0 13320 8320 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 6180 10820 8320 ;
    LAYER M8 ;
      RECT 2500 0 10820 2140 ;
    LAYER M8 ;
      RECT 10820 6660 13320 8320 ;
    LAYER M8 ;
      RECT 10820 0 13320 1660 ;
    LAYER M8 ;
      RECT 11660 0 13320 8320 ;
    LAYER M8 ;
      RECT 0 2980 10820 5340 ;
    LAYER M8 ;
      RECT 5000 5340 6740 5820 ;
    LAYER M8 ;
      RECT 5000 5340 6740 5820 ;
    LAYER M8 ;
      RECT 5000 2500 6740 2980 ;
    LAYER M5 ;
      RECT 6060 0 7260 8320 ;
    LAYER M5 ;
      RECT 2500 3560 10820 4760 ;
    LAYER M5 ;
      RECT 7860 5960 9060 8320 ;
    LAYER M5 ;
      RECT 7860 5360 10820 6560 ;
    LAYER M5 ;
      RECT 9660 7760 10820 8320 ;
    LAYER M5 ;
      RECT 9660 7160 10820 8320 ;
    LAYER M5 ;
      RECT 4260 5960 5460 8320 ;
    LAYER M5 ;
      RECT 2500 5360 5460 6560 ;
    LAYER M5 ;
      RECT 2500 7760 3660 8320 ;
    LAYER M5 ;
      RECT 2500 7160 3660 8320 ;
    LAYER M5 ;
      RECT 4260 0 5460 2360 ;
    LAYER M5 ;
      RECT 2500 1760 5460 2960 ;
    LAYER M5 ;
      RECT 2500 0 3660 560 ;
    LAYER M5 ;
      RECT 2500 0 3660 1160 ;
    LAYER M5 ;
      RECT 7860 0 9060 2360 ;
    LAYER M5 ;
      RECT 7860 1760 10820 2960 ;
    LAYER M5 ;
      RECT 9660 0 10820 560 ;
    LAYER M5 ;
      RECT 9660 0 10820 1160 ;
    LAYER M5 ;
      RECT 2500 7890 10820 8320 ;
    LAYER M5 ;
      RECT 2500 0 10820 430 ;
    LAYER M6 ;
      RECT 6960 5060 8160 8320 ;
    LAYER M6 ;
      RECT 6960 4460 10820 5660 ;
    LAYER M6 ;
      RECT 8760 6860 9960 8320 ;
    LAYER M6 ;
      RECT 8760 6260 10820 7460 ;
    LAYER M6 ;
      RECT 5160 5060 6360 8320 ;
    LAYER M6 ;
      RECT 2500 4460 6360 5660 ;
    LAYER M6 ;
      RECT 3360 6860 4560 8320 ;
    LAYER M6 ;
      RECT 2500 6260 4560 7460 ;
    LAYER M6 ;
      RECT 5160 0 6360 3260 ;
    LAYER M6 ;
      RECT 2500 2660 6360 3860 ;
    LAYER M6 ;
      RECT 3360 0 4560 1460 ;
    LAYER M6 ;
      RECT 2500 860 4560 2060 ;
    LAYER M6 ;
      RECT 6960 0 8160 3260 ;
    LAYER M6 ;
      RECT 6960 2660 10820 3860 ;
    LAYER M6 ;
      RECT 8760 0 9960 1460 ;
    LAYER M6 ;
      RECT 8760 860 10820 2060 ;
    LAYER M6 ;
      RECT 2500 7890 10820 8320 ;
    LAYER M6 ;
      RECT 2500 0 10820 430 ;
  END
END xc2_1
MACRO xc3_2.5
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc3_2.5 0 0 ;
  SIZE 18360 BY 28110 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 2500 27680 15860 28110 ;
      LAYER M5 ;
        RECT 8580 0 9780 28110 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 2500 0 15860 430 ;
      LAYER M5 ;
        RECT 8580 0 9780 28110 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 12875 15860 15235 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 16700 0 18360 28110 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 16075 15860 28110 ;
    LAYER M8 ;
      RECT 2500 0 15860 12035 ;
    LAYER M8 ;
      RECT 15860 26450 18360 28110 ;
    LAYER M8 ;
      RECT 15860 0 18360 1660 ;
    LAYER M8 ;
      RECT 16700 0 18360 28110 ;
    LAYER M8 ;
      RECT 0 12875 15860 15235 ;
    LAYER M8 ;
      RECT 5000 15235 6740 25610 ;
    LAYER M8 ;
      RECT 5000 15235 6740 25610 ;
    LAYER M8 ;
      RECT 5000 2500 6740 12875 ;
    LAYER M8 ;
      RECT 8310 15235 10050 25610 ;
    LAYER M8 ;
      RECT 8310 15235 10050 25610 ;
    LAYER M8 ;
      RECT 8310 2500 10050 12875 ;
    LAYER M8 ;
      RECT 11620 15235 13360 25610 ;
    LAYER M8 ;
      RECT 11620 15235 13360 25610 ;
    LAYER M8 ;
      RECT 11620 2500 13360 12875 ;
    LAYER M5 ;
      RECT 8580 0 9780 28110 ;
    LAYER M5 ;
      RECT 2500 13455 15860 14655 ;
    LAYER M5 ;
      RECT 10380 15855 11580 28110 ;
    LAYER M5 ;
      RECT 10380 15255 15860 16455 ;
    LAYER M5 ;
      RECT 12180 17655 13380 28110 ;
    LAYER M5 ;
      RECT 12180 17055 15860 18255 ;
    LAYER M5 ;
      RECT 13980 19455 15180 28110 ;
    LAYER M5 ;
      RECT 13980 18855 15860 20055 ;
    LAYER M5 ;
      RECT 15780 21255 15860 28110 ;
    LAYER M5 ;
      RECT 15780 20655 15860 21855 ;
    LAYER M5 ;
      RECT 6780 15855 7980 28110 ;
    LAYER M5 ;
      RECT 2500 15255 7980 16455 ;
    LAYER M5 ;
      RECT 4980 17655 6180 28110 ;
    LAYER M5 ;
      RECT 2500 17055 6180 18255 ;
    LAYER M5 ;
      RECT 3180 19455 4380 28110 ;
    LAYER M5 ;
      RECT 2500 18855 4380 20055 ;
    LAYER M5 ;
      RECT 2500 21255 2580 28110 ;
    LAYER M5 ;
      RECT 2500 20655 2580 21855 ;
    LAYER M5 ;
      RECT 6780 0 7980 12255 ;
    LAYER M5 ;
      RECT 2500 11655 7980 12855 ;
    LAYER M5 ;
      RECT 4980 0 6180 10455 ;
    LAYER M5 ;
      RECT 2500 9855 6180 11055 ;
    LAYER M5 ;
      RECT 3180 0 4380 8655 ;
    LAYER M5 ;
      RECT 2500 8055 4380 9255 ;
    LAYER M5 ;
      RECT 2500 0 2580 6855 ;
    LAYER M5 ;
      RECT 2500 6255 2580 7455 ;
    LAYER M5 ;
      RECT 10380 0 11580 12255 ;
    LAYER M5 ;
      RECT 10380 11655 15860 12855 ;
    LAYER M5 ;
      RECT 12180 0 13380 10455 ;
    LAYER M5 ;
      RECT 12180 9855 15860 11055 ;
    LAYER M5 ;
      RECT 13980 0 15180 8655 ;
    LAYER M5 ;
      RECT 13980 8055 15860 9255 ;
    LAYER M5 ;
      RECT 15780 0 15860 6855 ;
    LAYER M5 ;
      RECT 15780 6255 15860 7455 ;
    LAYER M5 ;
      RECT 2500 27680 15860 28110 ;
    LAYER M5 ;
      RECT 2500 0 15860 430 ;
    LAYER M6 ;
      RECT 9480 14955 10680 28110 ;
    LAYER M6 ;
      RECT 9480 14355 15860 15555 ;
    LAYER M6 ;
      RECT 11280 16755 12480 28110 ;
    LAYER M6 ;
      RECT 11280 16155 15860 17355 ;
    LAYER M6 ;
      RECT 13080 18555 14280 28110 ;
    LAYER M6 ;
      RECT 13080 17955 15860 19155 ;
    LAYER M6 ;
      RECT 14880 20355 15860 28110 ;
    LAYER M6 ;
      RECT 14880 19755 15860 20955 ;
    LAYER M6 ;
      RECT 7680 14955 8880 28110 ;
    LAYER M6 ;
      RECT 2500 14355 8880 15555 ;
    LAYER M6 ;
      RECT 5880 16755 7080 28110 ;
    LAYER M6 ;
      RECT 2500 16155 7080 17355 ;
    LAYER M6 ;
      RECT 4080 18555 5280 28110 ;
    LAYER M6 ;
      RECT 2500 17955 5280 19155 ;
    LAYER M6 ;
      RECT 2500 20355 3480 28110 ;
    LAYER M6 ;
      RECT 2500 19755 3480 20955 ;
    LAYER M6 ;
      RECT 7680 0 8880 13155 ;
    LAYER M6 ;
      RECT 2500 12555 8880 13755 ;
    LAYER M6 ;
      RECT 5880 0 7080 11355 ;
    LAYER M6 ;
      RECT 2500 10755 7080 11955 ;
    LAYER M6 ;
      RECT 4080 0 5280 9555 ;
    LAYER M6 ;
      RECT 2500 8955 5280 10155 ;
    LAYER M6 ;
      RECT 2500 0 3480 7755 ;
    LAYER M6 ;
      RECT 2500 7155 3480 8355 ;
    LAYER M6 ;
      RECT 9480 0 10680 13155 ;
    LAYER M6 ;
      RECT 9480 12555 15860 13755 ;
    LAYER M6 ;
      RECT 11280 0 12480 11355 ;
    LAYER M6 ;
      RECT 11280 10755 15860 11955 ;
    LAYER M6 ;
      RECT 13080 0 14280 9555 ;
    LAYER M6 ;
      RECT 13080 8955 15860 10155 ;
    LAYER M6 ;
      RECT 14880 0 15860 7755 ;
    LAYER M6 ;
      RECT 14880 7155 15860 8355 ;
    LAYER M6 ;
      RECT 2500 27680 15860 28110 ;
    LAYER M6 ;
      RECT 2500 0 15860 430 ;
  END
END xc3_2.5
MACRO xR0_8
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR0_8 0 0 ;
  SIZE 2280 BY 9320 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 235 320 9085 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1960 235 2050 9085 ;
    END
  END MINUS
  OBS
    LAYER PO ;
      RECT 200 220 2080 9100 ;
    LAYER RPO ;
      RECT 540 0 1740 9320 ;
    LAYER M1 ;
      RECT 230 235 320 9085 ;
    LAYER M1 ;
      RECT 1960 235 2050 9085 ;
    LAYER RH ;
      RECT 0 20 2280 9300 ;
  END
END xR0_8
MACRO xR1_4
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR1_4 0 0 ;
  SIZE 4270 BY 8490 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 235 320 8255 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 3950 235 4040 8255 ;
    END
  END MINUS
  OBS
    LAYER PO ;
      RECT 200 220 4070 8270 ;
    LAYER RPO ;
      RECT 540 0 3730 8490 ;
    LAYER M1 ;
      RECT 230 235 320 8255 ;
    LAYER M1 ;
      RECT 3950 235 4040 8255 ;
    LAYER RH ;
      RECT 0 20 4270 8470 ;
  END
END xR1_4
MACRO xR2_5
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR2_5 0 0 ;
  SIZE 14210 BY 3750 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 235 320 3515 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 13890 235 13980 3515 ;
    END
  END MINUS
  OBS
    LAYER PO ;
      RECT 200 220 14010 3530 ;
    LAYER RPO ;
      RECT 540 0 13670 3750 ;
    LAYER M1 ;
      RECT 230 235 320 3515 ;
    LAYER M1 ;
      RECT 13890 235 13980 3515 ;
    LAYER RH ;
      RECT 0 20 14210 3730 ;
  END
END xR2_5
MACRO xR3_9
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR3_9 0 0 ;
  SIZE 26730 BY 6910 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 235 320 6675 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 26410 235 26500 6675 ;
    END
  END MINUS
  OBS
    LAYER PO ;
      RECT 200 220 26530 6690 ;
    LAYER RPO ;
      RECT 540 0 26190 6910 ;
    LAYER M1 ;
      RECT 230 235 320 6675 ;
    LAYER M1 ;
      RECT 26410 235 26500 6675 ;
    LAYER RH ;
      RECT 0 20 26730 6890 ;
  END
END xR3_9
MACRO xwg1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xwg1 0 0 ;
  SIZE 77000 BY 38050 ;
  PIN GND1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 0 77000 2900 ;
      LAYER M9 ;
        RECT 1945 1000 75055 10338 ;
    END
  END GND1
  PIN GND2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 0 35150 77000 38050 ;
      LAYER M9 ;
        RECT 1945 27712 75055 37050 ;
    END
  END GND2
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1945 13856 75055 24194 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1945 13856 75055 24194 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 1945 13856 75055 24194 ;
    LAYER M9 ;
      RECT 1945 27712 75055 37050 ;
    LAYER M9 ;
      RECT 1945 1000 75055 10338 ;
    LAYER M9 ;
      RECT 0 35150 77000 38050 ;
    LAYER M9 ;
      RECT 0 0 77000 2900 ;
    LAYER M8 ;
      RECT 0 35150 77000 38050 ;
    LAYER M8 ;
      RECT 0 0 77000 2900 ;
    LAYER M8 ;
      RECT 0 0 2000 38050 ;
    LAYER M8 ;
      RECT 3000 0 5000 38050 ;
    LAYER M8 ;
      RECT 6000 0 8000 38050 ;
    LAYER M8 ;
      RECT 9000 0 11000 38050 ;
    LAYER M8 ;
      RECT 12000 0 14000 38050 ;
    LAYER M8 ;
      RECT 15000 0 17000 38050 ;
    LAYER M8 ;
      RECT 18000 0 20000 38050 ;
    LAYER M8 ;
      RECT 21000 0 23000 38050 ;
    LAYER M8 ;
      RECT 24000 0 26000 38050 ;
    LAYER M8 ;
      RECT 27000 0 29000 38050 ;
    LAYER M8 ;
      RECT 30000 0 32000 38050 ;
    LAYER M8 ;
      RECT 33000 0 35000 38050 ;
    LAYER M8 ;
      RECT 36000 0 38000 38050 ;
    LAYER M8 ;
      RECT 39000 0 41000 38050 ;
    LAYER M8 ;
      RECT 42000 0 44000 38050 ;
    LAYER M8 ;
      RECT 45000 0 47000 38050 ;
    LAYER M8 ;
      RECT 48000 0 50000 38050 ;
    LAYER M8 ;
      RECT 51000 0 53000 38050 ;
    LAYER M8 ;
      RECT 54000 0 56000 38050 ;
    LAYER M8 ;
      RECT 57000 0 59000 38050 ;
    LAYER M8 ;
      RECT 60000 0 62000 38050 ;
    LAYER M8 ;
      RECT 63000 0 65000 38050 ;
    LAYER M8 ;
      RECT 66000 0 68000 38050 ;
    LAYER M8 ;
      RECT 69000 0 71000 38050 ;
    LAYER M8 ;
      RECT 72000 0 74000 38050 ;
    LAYER M8 ;
      RECT 75000 0 77000 38050 ;
  END
END xwg1
