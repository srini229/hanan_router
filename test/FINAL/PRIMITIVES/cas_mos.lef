MACRO cas_mos
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN cas_mos 0 0 ;
  SIZE 9230 BY 8435 ;
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 700 3965 910 4615 ;
    END
  END GND
  PIN G2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 8318 2645 9230 4245 ;
    END
  END G2
  PIN SS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M7 ;
        RECT 0 4615 8065 5655 ;
    END
  END SS
  PIN DD
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1165 0 8065 2000 ;
    END
  END DD
  PIN GG
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1365 6435 7865 8435 ;
    END
  END GG
  OBS
    LAYER M4 ;
      RECT 6485 3915 6665 4615 ;
    LAYER M4 ;
      RECT 5925 3915 6105 4615 ;
    LAYER M4 ;
      RECT 7045 3915 7225 4615 ;
    LAYER M4 ;
      RECT 7605 3915 7785 4615 ;
    LAYER M4 ;
      RECT 4245 3915 4425 4615 ;
    LAYER M4 ;
      RECT 3685 3915 3865 4615 ;
    LAYER M4 ;
      RECT 4805 3915 4985 4615 ;
    LAYER M4 ;
      RECT 5365 3915 5545 4615 ;
    LAYER M4 ;
      RECT 2565 3915 2745 4615 ;
    LAYER M4 ;
      RECT 3125 3915 3305 4615 ;
    LAYER M4 ;
      RECT 2005 3915 2185 4615 ;
    LAYER M4 ;
      RECT 1445 3915 1625 4615 ;
    LAYER M4 ;
      RECT 1365 5935 7865 6115 ;
    LAYER M4 ;
      RECT 1365 6115 7865 6295 ;
    LAYER M4 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M4 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M4 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M4 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M4 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M4 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M4 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M4 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M4 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M4 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M4 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M4 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M4 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M4 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M4 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M4 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M4 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M4 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M4 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M4 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M4 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M4 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M4 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M4 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M4 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M4 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M4 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M4 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M4 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M4 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M4 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M4 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M4 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M4 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M4 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M4 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M4 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M4 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M4 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M4 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M4 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M4 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M4 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M4 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M4 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M4 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M4 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M4 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M4 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M4 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M4 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M4 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M4 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M4 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M4 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M4 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M4 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M4 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M4 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M4 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M4 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M4 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M4 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M4 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M4 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M4 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M4 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M4 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M4 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M4 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M4 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M4 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M4 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M4 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M4 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M4 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M4 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M4 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M4 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M4 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M4 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M4 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M4 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M4 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M4 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M4 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M4 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M4 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M4 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M4 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M4 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M4 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M4 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M4 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M4 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M4 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M4 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M4 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M4 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M4 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M3 ;
      RECT 7855 2645 8545 2825 ;
    LAYER M3 ;
      RECT 7855 4065 8545 4245 ;
    LAYER M3 ;
      RECT 8318 2645 9230 4245 ;
    LAYER M3 ;
      RECT 1365 5755 7865 5935 ;
    LAYER M3 ;
      RECT 1365 2645 7865 2825 ;
    LAYER M3 ;
      RECT 1365 4065 7865 4245 ;
    LAYER M3 ;
      RECT 1365 5935 7865 6115 ;
    LAYER M3 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M3 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M3 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M3 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M3 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M3 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M3 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M3 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M3 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M3 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M3 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M3 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M3 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M3 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M3 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M3 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M3 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M3 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M3 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M3 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M3 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M3 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M3 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M3 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M3 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M3 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M3 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M3 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M3 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M3 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M3 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M3 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M3 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M3 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M3 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M3 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M3 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M3 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M3 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M3 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M3 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M3 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M3 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M3 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M3 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M3 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M3 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M3 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M3 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M3 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M3 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M3 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M3 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M3 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M3 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M3 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M3 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M3 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M3 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M3 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M3 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M3 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M3 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M3 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M3 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M3 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M3 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M3 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M3 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M3 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M3 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M3 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M3 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M3 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M3 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M3 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M3 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M3 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M3 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M3 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M3 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M3 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M3 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M3 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M3 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M3 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M3 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M3 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M3 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M3 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M3 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M3 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M3 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M3 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M3 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M3 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M3 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M3 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M3 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M3 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M5 ;
      RECT 7885 1765 8065 2925 ;
    LAYER M5 ;
      RECT 5645 1765 5825 2925 ;
    LAYER M5 ;
      RECT 6205 1765 6385 2925 ;
    LAYER M5 ;
      RECT 6765 1765 6945 2925 ;
    LAYER M5 ;
      RECT 7325 1765 7505 2925 ;
    LAYER M5 ;
      RECT 3405 1765 3585 2925 ;
    LAYER M5 ;
      RECT 3965 1765 4145 2925 ;
    LAYER M5 ;
      RECT 4525 1765 4705 2925 ;
    LAYER M5 ;
      RECT 5085 1765 5265 2925 ;
    LAYER M5 ;
      RECT 2285 1765 2465 2925 ;
    LAYER M5 ;
      RECT 2845 1765 3025 2925 ;
    LAYER M5 ;
      RECT 1725 1765 1905 2925 ;
    LAYER M5 ;
      RECT 1165 1765 1345 2925 ;
    LAYER M5 ;
      RECT 5925 3915 6105 4615 ;
    LAYER M5 ;
      RECT 6485 3915 6665 4615 ;
    LAYER M5 ;
      RECT 7045 3915 7225 4615 ;
    LAYER M5 ;
      RECT 7605 3915 7785 4615 ;
    LAYER M5 ;
      RECT 3685 3915 3865 4615 ;
    LAYER M5 ;
      RECT 4245 3915 4425 4615 ;
    LAYER M5 ;
      RECT 4805 3915 4985 4615 ;
    LAYER M5 ;
      RECT 5365 3915 5545 4615 ;
    LAYER M5 ;
      RECT 2565 3915 2745 4615 ;
    LAYER M5 ;
      RECT 3125 3915 3305 4615 ;
    LAYER M5 ;
      RECT 2005 3915 2185 4615 ;
    LAYER M5 ;
      RECT 1445 3915 1625 4615 ;
    LAYER M5 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M5 ;
      RECT 1365 6295 7865 6475 ;
    LAYER M5 ;
      RECT 1365 6115 7865 6295 ;
    LAYER M5 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M5 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M5 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M5 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M5 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M5 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M5 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M5 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M5 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M5 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M5 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M5 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M5 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M5 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M5 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M5 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M5 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M5 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M5 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M5 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M5 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M5 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M5 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M5 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M5 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M5 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M5 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M5 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M5 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M5 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M5 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M5 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M5 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M5 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M5 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M5 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M5 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M5 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M5 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M5 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M5 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M5 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M5 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M5 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M5 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M5 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M5 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M5 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M5 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M5 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M5 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M5 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M5 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M5 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M5 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M5 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M5 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M5 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M5 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M5 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M5 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M5 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M5 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M5 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M5 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M5 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M5 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M5 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M5 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M5 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M5 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M5 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M5 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M5 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M5 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M5 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M6 ;
      RECT 7885 1765 8065 2925 ;
    LAYER M6 ;
      RECT 5645 1765 5825 2925 ;
    LAYER M6 ;
      RECT 6205 1765 6385 2925 ;
    LAYER M6 ;
      RECT 6765 1765 6945 2925 ;
    LAYER M6 ;
      RECT 7325 1765 7505 2925 ;
    LAYER M6 ;
      RECT 3405 1765 3585 2925 ;
    LAYER M6 ;
      RECT 3965 1765 4145 2925 ;
    LAYER M6 ;
      RECT 4525 1765 4705 2925 ;
    LAYER M6 ;
      RECT 5085 1765 5265 2925 ;
    LAYER M6 ;
      RECT 2285 1765 2465 2925 ;
    LAYER M6 ;
      RECT 2845 1765 3025 2925 ;
    LAYER M6 ;
      RECT 1725 1765 1905 2925 ;
    LAYER M6 ;
      RECT 1165 1765 1345 2925 ;
    LAYER M6 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M6 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M6 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M6 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M6 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M6 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M6 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M6 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M6 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M6 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M6 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M6 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M6 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M6 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M6 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M6 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M6 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M6 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M6 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M6 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M6 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M6 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M6 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M6 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M6 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M6 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M6 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M6 ;
      RECT 1365 6295 7865 6475 ;
    LAYER M6 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M6 ;
      RECT 1365 6475 7865 6655 ;
    LAYER M6 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M6 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M6 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M6 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M6 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M6 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M6 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M6 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M6 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M6 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M6 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M6 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M6 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M6 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M6 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M6 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M6 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M6 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M6 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M6 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M6 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M6 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M6 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M6 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M6 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M6 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M7 ;
      RECT 7885 1765 8065 2925 ;
    LAYER M7 ;
      RECT 6765 1765 6945 2925 ;
    LAYER M7 ;
      RECT 6205 1765 6385 2925 ;
    LAYER M7 ;
      RECT 5645 1765 5825 2925 ;
    LAYER M7 ;
      RECT 7325 1765 7505 2925 ;
    LAYER M7 ;
      RECT 4525 1765 4705 2925 ;
    LAYER M7 ;
      RECT 3965 1765 4145 2925 ;
    LAYER M7 ;
      RECT 2285 1765 2465 2925 ;
    LAYER M7 ;
      RECT 3405 1765 3585 2925 ;
    LAYER M7 ;
      RECT 5085 1765 5265 2925 ;
    LAYER M7 ;
      RECT 2845 1765 3025 2925 ;
    LAYER M7 ;
      RECT 1725 1765 1905 2925 ;
    LAYER M7 ;
      RECT 1165 1765 1345 2925 ;
    LAYER M7 ;
      RECT 0 4615 8065 5655 ;
    LAYER M7 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M7 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M7 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M7 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M7 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M7 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M7 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M7 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M7 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M7 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M7 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M7 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M7 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M7 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M7 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M7 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M7 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M7 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M7 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M7 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M7 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M7 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M7 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M7 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M7 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M7 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M7 ;
      RECT 1365 6655 7865 7175 ;
    LAYER M7 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M7 ;
      RECT 1365 6475 7865 6655 ;
    LAYER M7 ;
      RECT 1165 1235 8065 1765 ;
    LAYER PO ;
      RECT 1365 5735 7865 5945 ;
    LAYER PO ;
      RECT 1365 4495 1425 4635 ;
    LAYER PO ;
      RECT 1365 5635 1425 5735 ;
    LAYER PO ;
      RECT 1645 4495 1705 4635 ;
    LAYER PO ;
      RECT 1645 5635 1705 5735 ;
    LAYER PO ;
      RECT 1925 4495 1985 4635 ;
    LAYER PO ;
      RECT 1925 5635 1985 5735 ;
    LAYER PO ;
      RECT 2205 4495 2265 4635 ;
    LAYER PO ;
      RECT 2205 5635 2265 5735 ;
    LAYER PO ;
      RECT 2485 4495 2545 4635 ;
    LAYER PO ;
      RECT 2485 5635 2545 5735 ;
    LAYER PO ;
      RECT 2765 4495 2825 4635 ;
    LAYER PO ;
      RECT 2765 5635 2825 5735 ;
    LAYER PO ;
      RECT 3045 4495 3105 4635 ;
    LAYER PO ;
      RECT 3045 5635 3105 5735 ;
    LAYER PO ;
      RECT 3325 4495 3385 4635 ;
    LAYER PO ;
      RECT 3325 5635 3385 5735 ;
    LAYER PO ;
      RECT 3605 4495 3665 4635 ;
    LAYER PO ;
      RECT 3605 5635 3665 5735 ;
    LAYER PO ;
      RECT 3885 4495 3945 4635 ;
    LAYER PO ;
      RECT 3885 5635 3945 5735 ;
    LAYER PO ;
      RECT 4165 4495 4225 4635 ;
    LAYER PO ;
      RECT 4165 5635 4225 5735 ;
    LAYER PO ;
      RECT 4445 4495 4505 4635 ;
    LAYER PO ;
      RECT 4445 5635 4505 5735 ;
    LAYER PO ;
      RECT 4725 4495 4785 4635 ;
    LAYER PO ;
      RECT 4725 5635 4785 5735 ;
    LAYER PO ;
      RECT 5005 4495 5065 4635 ;
    LAYER PO ;
      RECT 5005 5635 5065 5735 ;
    LAYER PO ;
      RECT 5285 4495 5345 4635 ;
    LAYER PO ;
      RECT 5285 5635 5345 5735 ;
    LAYER PO ;
      RECT 5565 4495 5625 4635 ;
    LAYER PO ;
      RECT 5565 5635 5625 5735 ;
    LAYER PO ;
      RECT 5845 4495 5905 4635 ;
    LAYER PO ;
      RECT 5845 5635 5905 5735 ;
    LAYER PO ;
      RECT 6125 4495 6185 4635 ;
    LAYER PO ;
      RECT 6125 5635 6185 5735 ;
    LAYER PO ;
      RECT 6405 4495 6465 4635 ;
    LAYER PO ;
      RECT 6405 5635 6465 5735 ;
    LAYER PO ;
      RECT 6685 4495 6745 4635 ;
    LAYER PO ;
      RECT 6685 5635 6745 5735 ;
    LAYER PO ;
      RECT 6965 4495 7025 4635 ;
    LAYER PO ;
      RECT 6965 5635 7025 5735 ;
    LAYER PO ;
      RECT 7245 4495 7305 4635 ;
    LAYER PO ;
      RECT 7245 5635 7305 5735 ;
    LAYER PO ;
      RECT 7525 4495 7585 4635 ;
    LAYER PO ;
      RECT 7525 5635 7585 5735 ;
    LAYER PO ;
      RECT 7805 4495 7865 4635 ;
    LAYER PO ;
      RECT 7805 5635 7865 5735 ;
    LAYER PO ;
      RECT 7805 4635 7865 5635 ;
    LAYER PO ;
      RECT 7525 4635 7585 5635 ;
    LAYER PO ;
      RECT 7245 4635 7305 5635 ;
    LAYER PO ;
      RECT 6965 4635 7025 5635 ;
    LAYER PO ;
      RECT 6685 4635 6745 5635 ;
    LAYER PO ;
      RECT 6405 4635 6465 5635 ;
    LAYER PO ;
      RECT 6125 4635 6185 5635 ;
    LAYER PO ;
      RECT 5845 4635 5905 5635 ;
    LAYER PO ;
      RECT 5565 4635 5625 5635 ;
    LAYER PO ;
      RECT 5285 4635 5345 5635 ;
    LAYER PO ;
      RECT 5005 4635 5065 5635 ;
    LAYER PO ;
      RECT 4725 4635 4785 5635 ;
    LAYER PO ;
      RECT 4445 4635 4505 5635 ;
    LAYER PO ;
      RECT 4165 4635 4225 5635 ;
    LAYER PO ;
      RECT 3885 4635 3945 5635 ;
    LAYER PO ;
      RECT 3605 4635 3665 5635 ;
    LAYER PO ;
      RECT 3325 4635 3385 5635 ;
    LAYER PO ;
      RECT 3045 4635 3105 5635 ;
    LAYER PO ;
      RECT 2765 4635 2825 5635 ;
    LAYER PO ;
      RECT 2485 4635 2545 5635 ;
    LAYER PO ;
      RECT 2205 4635 2265 5635 ;
    LAYER PO ;
      RECT 1925 4635 1985 5635 ;
    LAYER PO ;
      RECT 1645 4635 1705 5635 ;
    LAYER PO ;
      RECT 1365 4635 1425 5635 ;
    LAYER PO ;
      RECT 1365 2635 7865 2845 ;
    LAYER PO ;
      RECT 1365 4045 7865 4255 ;
    LAYER PO ;
      RECT 1365 2845 1425 2945 ;
    LAYER PO ;
      RECT 1365 3945 1425 4045 ;
    LAYER PO ;
      RECT 1645 2845 1705 2945 ;
    LAYER PO ;
      RECT 1645 3945 1705 4045 ;
    LAYER PO ;
      RECT 1925 2845 1985 2945 ;
    LAYER PO ;
      RECT 1925 3945 1985 4045 ;
    LAYER PO ;
      RECT 2205 2845 2265 2945 ;
    LAYER PO ;
      RECT 2205 3945 2265 4045 ;
    LAYER PO ;
      RECT 2485 2845 2545 2945 ;
    LAYER PO ;
      RECT 2485 3945 2545 4045 ;
    LAYER PO ;
      RECT 2765 2845 2825 2945 ;
    LAYER PO ;
      RECT 2765 3945 2825 4045 ;
    LAYER PO ;
      RECT 3045 2845 3105 2945 ;
    LAYER PO ;
      RECT 3045 3945 3105 4045 ;
    LAYER PO ;
      RECT 3325 2845 3385 2945 ;
    LAYER PO ;
      RECT 3325 3945 3385 4045 ;
    LAYER PO ;
      RECT 3605 2845 3665 2945 ;
    LAYER PO ;
      RECT 3605 3945 3665 4045 ;
    LAYER PO ;
      RECT 3885 2845 3945 2945 ;
    LAYER PO ;
      RECT 3885 3945 3945 4045 ;
    LAYER PO ;
      RECT 4165 2845 4225 2945 ;
    LAYER PO ;
      RECT 4165 3945 4225 4045 ;
    LAYER PO ;
      RECT 4445 2845 4505 2945 ;
    LAYER PO ;
      RECT 4445 3945 4505 4045 ;
    LAYER PO ;
      RECT 4725 2845 4785 2945 ;
    LAYER PO ;
      RECT 4725 3945 4785 4045 ;
    LAYER PO ;
      RECT 5005 2845 5065 2945 ;
    LAYER PO ;
      RECT 5005 3945 5065 4045 ;
    LAYER PO ;
      RECT 5285 2845 5345 2945 ;
    LAYER PO ;
      RECT 5285 3945 5345 4045 ;
    LAYER PO ;
      RECT 5565 2845 5625 2945 ;
    LAYER PO ;
      RECT 5565 3945 5625 4045 ;
    LAYER PO ;
      RECT 5845 2845 5905 2945 ;
    LAYER PO ;
      RECT 5845 3945 5905 4045 ;
    LAYER PO ;
      RECT 6125 2845 6185 2945 ;
    LAYER PO ;
      RECT 6125 3945 6185 4045 ;
    LAYER PO ;
      RECT 6405 2845 6465 2945 ;
    LAYER PO ;
      RECT 6405 3945 6465 4045 ;
    LAYER PO ;
      RECT 6685 2845 6745 2945 ;
    LAYER PO ;
      RECT 6685 3945 6745 4045 ;
    LAYER PO ;
      RECT 6965 2845 7025 2945 ;
    LAYER PO ;
      RECT 6965 3945 7025 4045 ;
    LAYER PO ;
      RECT 7245 2845 7305 2945 ;
    LAYER PO ;
      RECT 7245 3945 7305 4045 ;
    LAYER PO ;
      RECT 7525 2845 7585 2945 ;
    LAYER PO ;
      RECT 7525 3945 7585 4045 ;
    LAYER PO ;
      RECT 7805 2845 7865 2945 ;
    LAYER PO ;
      RECT 7805 3945 7865 4045 ;
    LAYER PO ;
      RECT 7805 2945 7865 3945 ;
    LAYER PO ;
      RECT 7525 2945 7585 3945 ;
    LAYER PO ;
      RECT 7245 2945 7305 3945 ;
    LAYER PO ;
      RECT 6965 2945 7025 3945 ;
    LAYER PO ;
      RECT 6685 2945 6745 3945 ;
    LAYER PO ;
      RECT 6405 2945 6465 3945 ;
    LAYER PO ;
      RECT 6125 2945 6185 3945 ;
    LAYER PO ;
      RECT 5845 2945 5905 3945 ;
    LAYER PO ;
      RECT 5565 2945 5625 3945 ;
    LAYER PO ;
      RECT 5285 2945 5345 3945 ;
    LAYER PO ;
      RECT 5005 2945 5065 3945 ;
    LAYER PO ;
      RECT 4725 2945 4785 3945 ;
    LAYER PO ;
      RECT 4445 2945 4505 3945 ;
    LAYER PO ;
      RECT 4165 2945 4225 3945 ;
    LAYER PO ;
      RECT 3885 2945 3945 3945 ;
    LAYER PO ;
      RECT 3605 2945 3665 3945 ;
    LAYER PO ;
      RECT 3325 2945 3385 3945 ;
    LAYER PO ;
      RECT 3045 2945 3105 3945 ;
    LAYER PO ;
      RECT 2765 2945 2825 3945 ;
    LAYER PO ;
      RECT 2485 2945 2545 3945 ;
    LAYER PO ;
      RECT 2205 2945 2265 3945 ;
    LAYER PO ;
      RECT 1925 2945 1985 3945 ;
    LAYER PO ;
      RECT 1645 2945 1705 3945 ;
    LAYER PO ;
      RECT 1365 2945 1425 3945 ;
    LAYER M1 ;
      RECT 1490 4615 1580 5655 ;
    LAYER M1 ;
      RECT 1770 4615 1860 5655 ;
    LAYER M1 ;
      RECT 2050 4615 2140 5655 ;
    LAYER M1 ;
      RECT 2330 4615 2420 5655 ;
    LAYER M1 ;
      RECT 2610 4615 2700 5655 ;
    LAYER M1 ;
      RECT 2890 4615 2980 5655 ;
    LAYER M1 ;
      RECT 3170 4615 3260 5655 ;
    LAYER M1 ;
      RECT 3450 4615 3540 5655 ;
    LAYER M1 ;
      RECT 3730 4615 3820 5655 ;
    LAYER M1 ;
      RECT 4010 4615 4100 5655 ;
    LAYER M1 ;
      RECT 4290 4615 4380 5655 ;
    LAYER M1 ;
      RECT 4570 4615 4660 5655 ;
    LAYER M1 ;
      RECT 4850 4615 4940 5655 ;
    LAYER M1 ;
      RECT 5130 4615 5220 5655 ;
    LAYER M1 ;
      RECT 5410 4615 5500 5655 ;
    LAYER M1 ;
      RECT 5690 4615 5780 5655 ;
    LAYER M1 ;
      RECT 5970 4615 6060 5655 ;
    LAYER M1 ;
      RECT 6250 4615 6340 5655 ;
    LAYER M1 ;
      RECT 6530 4615 6620 5655 ;
    LAYER M1 ;
      RECT 6810 4615 6900 5655 ;
    LAYER M1 ;
      RECT 7090 4615 7180 5655 ;
    LAYER M1 ;
      RECT 7370 4615 7460 5655 ;
    LAYER M1 ;
      RECT 7650 4615 7740 5655 ;
    LAYER M1 ;
      RECT 7930 4615 8020 5655 ;
    LAYER M1 ;
      RECT 1210 4615 1300 5655 ;
    LAYER M1 ;
      RECT 1490 2925 1580 3965 ;
    LAYER M1 ;
      RECT 1770 2925 1860 3965 ;
    LAYER M1 ;
      RECT 2050 2925 2140 3965 ;
    LAYER M1 ;
      RECT 2330 2925 2420 3965 ;
    LAYER M1 ;
      RECT 2610 2925 2700 3965 ;
    LAYER M1 ;
      RECT 2890 2925 2980 3965 ;
    LAYER M1 ;
      RECT 3170 2925 3260 3965 ;
    LAYER M1 ;
      RECT 3450 2925 3540 3965 ;
    LAYER M1 ;
      RECT 3730 2925 3820 3965 ;
    LAYER M1 ;
      RECT 4010 2925 4100 3965 ;
    LAYER M1 ;
      RECT 4290 2925 4380 3965 ;
    LAYER M1 ;
      RECT 4570 2925 4660 3965 ;
    LAYER M1 ;
      RECT 4850 2925 4940 3965 ;
    LAYER M1 ;
      RECT 5130 2925 5220 3965 ;
    LAYER M1 ;
      RECT 5410 2925 5500 3965 ;
    LAYER M1 ;
      RECT 5690 2925 5780 3965 ;
    LAYER M1 ;
      RECT 5970 2925 6060 3965 ;
    LAYER M1 ;
      RECT 6250 2925 6340 3965 ;
    LAYER M1 ;
      RECT 6530 2925 6620 3965 ;
    LAYER M1 ;
      RECT 6810 2925 6900 3965 ;
    LAYER M1 ;
      RECT 7090 2925 7180 3965 ;
    LAYER M1 ;
      RECT 7370 2925 7460 3965 ;
    LAYER M1 ;
      RECT 7650 2925 7740 3965 ;
    LAYER M1 ;
      RECT 7930 2925 8020 3965 ;
    LAYER M1 ;
      RECT 1210 2925 1300 3965 ;
    LAYER M1 ;
      RECT 1365 5755 7865 5935 ;
    LAYER M1 ;
      RECT 1365 2645 7865 2825 ;
    LAYER M1 ;
      RECT 1365 4065 7865 4245 ;
    LAYER M1 ;
      RECT 8320 3965 8530 4615 ;
    LAYER M1 ;
      RECT 700 3965 910 4615 ;
    LAYER M1 ;
      RECT 8320 2485 8530 2925 ;
    LAYER M1 ;
      RECT 700 2485 910 2925 ;
    LAYER M1 ;
      RECT 700 5655 910 6095 ;
    LAYER M1 ;
      RECT 8320 5655 8530 6095 ;
    LAYER M1 ;
      RECT 700 6095 8530 6315 ;
    LAYER M1 ;
      RECT 700 2265 8530 2485 ;
    LAYER M1 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M1 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M1 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M1 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M1 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M1 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M1 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M1 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M1 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M1 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M1 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M1 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M1 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M1 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M1 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M1 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M1 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M1 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M1 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M1 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M1 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M1 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M1 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M1 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M1 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M1 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M1 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M1 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M1 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M1 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M1 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M1 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M1 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M1 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M1 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M1 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M1 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M1 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M1 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M1 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M1 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M1 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M1 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M1 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M1 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M1 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M1 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M1 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M1 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M1 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M1 ;
      RECT 1365 5795 7865 5885 ;
    LAYER M1 ;
      RECT 8320 4615 8530 5655 ;
    LAYER M1 ;
      RECT 700 4615 910 5655 ;
    LAYER M1 ;
      RECT 1365 2695 7865 2785 ;
    LAYER M1 ;
      RECT 1365 4105 7865 4195 ;
    LAYER M1 ;
      RECT 8320 2925 8530 3965 ;
    LAYER M1 ;
      RECT 700 2925 910 3965 ;
    LAYER M2 ;
      RECT 1365 5755 7865 5935 ;
    LAYER M2 ;
      RECT 1365 2645 7865 2825 ;
    LAYER M2 ;
      RECT 1365 4065 7865 4245 ;
    LAYER M2 ;
      RECT 1365 5755 7865 5935 ;
    LAYER M2 ;
      RECT 1365 2645 7865 2825 ;
    LAYER M2 ;
      RECT 1365 4065 7865 4245 ;
    LAYER M2 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M2 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M2 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M2 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M2 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M2 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M2 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M2 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M2 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M2 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M2 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M2 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M2 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M2 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M2 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M2 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M2 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M2 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M2 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M2 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M2 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M2 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M2 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M2 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M2 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M2 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M2 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M2 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M2 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M2 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M2 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M2 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M2 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M2 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M2 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M2 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M2 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M2 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M2 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M2 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M2 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M2 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M2 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M2 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M2 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M2 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M2 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M2 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M2 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M2 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M2 ;
      RECT 2285 2925 2465 3965 ;
    LAYER M2 ;
      RECT 2845 2925 3025 3965 ;
    LAYER M2 ;
      RECT 3405 2925 3585 3965 ;
    LAYER M2 ;
      RECT 3965 2925 4145 3965 ;
    LAYER M2 ;
      RECT 4525 2925 4705 3965 ;
    LAYER M2 ;
      RECT 5085 2925 5265 3965 ;
    LAYER M2 ;
      RECT 7325 2925 7505 3965 ;
    LAYER M2 ;
      RECT 6765 2925 6945 3965 ;
    LAYER M2 ;
      RECT 6205 2925 6385 3965 ;
    LAYER M2 ;
      RECT 5645 2925 5825 3965 ;
    LAYER M2 ;
      RECT 1445 2925 1625 3965 ;
    LAYER M2 ;
      RECT 2005 2925 2185 3965 ;
    LAYER M2 ;
      RECT 3125 2925 3305 3965 ;
    LAYER M2 ;
      RECT 2565 2925 2745 3965 ;
    LAYER M2 ;
      RECT 5365 2925 5545 3965 ;
    LAYER M2 ;
      RECT 4805 2925 4985 3965 ;
    LAYER M2 ;
      RECT 4245 2925 4425 3965 ;
    LAYER M2 ;
      RECT 3685 2925 3865 3965 ;
    LAYER M2 ;
      RECT 7045 2925 7225 3965 ;
    LAYER M2 ;
      RECT 6485 2925 6665 3965 ;
    LAYER M2 ;
      RECT 5925 2925 6105 3965 ;
    LAYER M2 ;
      RECT 1725 2925 1905 3965 ;
    LAYER M2 ;
      RECT 7885 2925 8065 3965 ;
    LAYER M2 ;
      RECT 1165 2925 1345 3965 ;
    LAYER M2 ;
      RECT 7605 2925 7785 3965 ;
    LAYER M2 ;
      RECT 5925 4615 6105 5655 ;
    LAYER M2 ;
      RECT 6485 4615 6665 5655 ;
    LAYER M2 ;
      RECT 7045 4615 7225 5655 ;
    LAYER M2 ;
      RECT 7605 4615 7785 5655 ;
    LAYER M2 ;
      RECT 3685 4615 3865 5655 ;
    LAYER M2 ;
      RECT 4245 4615 4425 5655 ;
    LAYER M2 ;
      RECT 4805 4615 4985 5655 ;
    LAYER M2 ;
      RECT 5365 4615 5545 5655 ;
    LAYER M2 ;
      RECT 2565 4615 2745 5655 ;
    LAYER M2 ;
      RECT 3125 4615 3305 5655 ;
    LAYER M2 ;
      RECT 2005 4615 2185 5655 ;
    LAYER M2 ;
      RECT 1445 4615 1625 5655 ;
    LAYER M2 ;
      RECT 7885 4615 8065 5655 ;
    LAYER M2 ;
      RECT 5645 4615 5825 5655 ;
    LAYER M2 ;
      RECT 6205 4615 6385 5655 ;
    LAYER M2 ;
      RECT 6765 4615 6945 5655 ;
    LAYER M2 ;
      RECT 7325 4615 7505 5655 ;
    LAYER M2 ;
      RECT 5085 4615 5265 5655 ;
    LAYER M2 ;
      RECT 4525 4615 4705 5655 ;
    LAYER M2 ;
      RECT 3965 4615 4145 5655 ;
    LAYER M2 ;
      RECT 3405 4615 3585 5655 ;
    LAYER M2 ;
      RECT 2845 4615 3025 5655 ;
    LAYER M2 ;
      RECT 2285 4615 2465 5655 ;
    LAYER M2 ;
      RECT 1725 4615 1905 5655 ;
    LAYER M2 ;
      RECT 1165 4615 1345 5655 ;
    LAYER M8 ;
      RECT 1365 6655 7865 7175 ;
    LAYER M8 ;
      RECT 1365 7175 7865 7695 ;
    LAYER M8 ;
      RECT 1165 740 8065 1260 ;
    LAYER M8 ;
      RECT 1165 1235 8065 1765 ;
    LAYER M9 ;
      RECT 1365 6435 7865 8435 ;
    LAYER M9 ;
      RECT 1165 0 8065 2000 ;
  END
END cas_mos
