MACRO xR1_4
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR1_4 0 0 ;
  SIZE 4270 BY 8490 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 235 320 8255 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 3950 235 4040 8255 ;
    END
  END MINUS
  OBS
    LAYER PO ;
      RECT 200 220 4070 8270 ;
    LAYER RPO ;
      RECT 540 0 3730 8490 ;
    LAYER M1 ;
      RECT 230 235 320 8255 ;
    LAYER M1 ;
      RECT 3950 235 4040 8255 ;
    LAYER RH ;
      RECT 0 20 4270 8470 ;
  END
END xR1_4
