MACRO gate_ind_x.1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN gate_ind_x.1 0 0 ;
  SIZE 119600 BY 111600 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 116600 57425 119600 60425 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 116600 51175 119600 54175 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 101600 50800 111600 60800 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 72600 57425 88100 60425 ;
    LAYER M9 ;
      RECT 85100 57425 119600 60425 ;
    LAYER M9 ;
      RECT 23500 25060 119600 86540 ;
    LAYER M1 ;
      RECT 0 0 111600 111600 ;
  END
END gate_ind_x.1
