MACRO xR3_9
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR3_9 0 0 ;
  SIZE 26730 BY 6910 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 235 320 6675 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 26410 235 26500 6675 ;
    END
  END MINUS
  OBS
    LAYER PO ;
      RECT 200 220 26530 6690 ;
    LAYER RPO ;
      RECT 540 0 26190 6910 ;
    LAYER M1 ;
      RECT 230 235 320 6675 ;
    LAYER M1 ;
      RECT 26410 235 26500 6675 ;
    LAYER RH ;
      RECT 0 20 26730 6890 ;
  END
END xR3_9
