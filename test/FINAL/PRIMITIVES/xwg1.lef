MACRO xwg1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xwg1 0 0 ;
  SIZE 77000 BY 38050 ;
  PIN GND1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 33331 1000 43669 10338 ;
    END
  END GND1
  PIN GND2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 33331 27712 43669 37050 ;
    END
  END GND2
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 1945 13856 12283 24194 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 64717 13856 75055 24194 ;
    END
  END P2
  OBS
    LAYER M9 ;
      RECT 1945 13856 75055 24194 ;
    LAYER M9 ;
      RECT 1945 27712 75055 37050 ;
    LAYER M9 ;
      RECT 1945 1000 75055 10338 ;
    LAYER M9 ;
      RECT 0 35150 77000 38050 ;
    LAYER M9 ;
      RECT 0 0 77000 2900 ;
    LAYER M8 ;
      RECT 0 35150 77000 38050 ;
    LAYER M8 ;
      RECT 0 0 77000 2900 ;
    LAYER M8 ;
      RECT 0 0 2000 38050 ;
    LAYER M8 ;
      RECT 3000 0 5000 38050 ;
    LAYER M8 ;
      RECT 6000 0 8000 38050 ;
    LAYER M8 ;
      RECT 9000 0 11000 38050 ;
    LAYER M8 ;
      RECT 12000 0 14000 38050 ;
    LAYER M8 ;
      RECT 15000 0 17000 38050 ;
    LAYER M8 ;
      RECT 18000 0 20000 38050 ;
    LAYER M8 ;
      RECT 21000 0 23000 38050 ;
    LAYER M8 ;
      RECT 24000 0 26000 38050 ;
    LAYER M8 ;
      RECT 27000 0 29000 38050 ;
    LAYER M8 ;
      RECT 30000 0 32000 38050 ;
    LAYER M8 ;
      RECT 33000 0 35000 38050 ;
    LAYER M8 ;
      RECT 36000 0 38000 38050 ;
    LAYER M8 ;
      RECT 39000 0 41000 38050 ;
    LAYER M8 ;
      RECT 42000 0 44000 38050 ;
    LAYER M8 ;
      RECT 45000 0 47000 38050 ;
    LAYER M8 ;
      RECT 48000 0 50000 38050 ;
    LAYER M8 ;
      RECT 51000 0 53000 38050 ;
    LAYER M8 ;
      RECT 54000 0 56000 38050 ;
    LAYER M8 ;
      RECT 57000 0 59000 38050 ;
    LAYER M8 ;
      RECT 60000 0 62000 38050 ;
    LAYER M8 ;
      RECT 63000 0 65000 38050 ;
    LAYER M8 ;
      RECT 66000 0 68000 38050 ;
    LAYER M8 ;
      RECT 69000 0 71000 38050 ;
    LAYER M8 ;
      RECT 72000 0 74000 38050 ;
    LAYER M8 ;
      RECT 75000 0 77000 38050 ;
  END
END xwg1
