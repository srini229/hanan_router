MACRO drain_ind_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN drain_ind_x.25 0 0 ;
  SIZE 117445 BY 120070 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 85195 54285 117445 62785 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 23375 20750 83195 120070 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 106570 106570 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 64195 54285 93695 62785 ;
    LAYER M9 ;
      RECT 85195 54285 117445 62785 ;
    LAYER M9 ;
      RECT 23375 20750 83195 120070 ;
    LAYER M1 ;
      RECT 0 0 106570 106570 ;
  END
END drain_ind_x.25
