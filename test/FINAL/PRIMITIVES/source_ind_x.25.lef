MACRO source_ind_x.25
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN source_ind_x.25 0 0 ;
  SIZE 134655 BY 137370 ;
  PIN P1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 104280 64125 134655 71625 ;
    END
  END P1
  PIN P2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M9 ;
        RECT 23965 21250 100905 137370 ;
    END
  END P2
  PIN GND
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 124870 124870 ;
    END
  END GND
  OBS
    LAYER M8 ;
      RECT 82530 64125 111780 71625 ;
    LAYER M9 ;
      RECT 104280 64125 134655 71625 ;
    LAYER M9 ;
      RECT 23965 21250 100905 137370 ;
    LAYER M1 ;
      RECT 0 0 124870 124870 ;
  END
END source_ind_x.25
