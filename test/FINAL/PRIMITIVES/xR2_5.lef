MACRO xR2_5
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR2_5 0 0 ;
  SIZE 14210 BY 3750 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 235 320 3515 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 13890 235 13980 3515 ;
    END
  END MINUS
  OBS
    LAYER PO ;
      RECT 200 220 14010 3530 ;
    LAYER RPO ;
      RECT 540 0 13670 3750 ;
    LAYER M1 ;
      RECT 230 235 320 3515 ;
    LAYER M1 ;
      RECT 13890 235 13980 3515 ;
    LAYER RH ;
      RECT 0 20 14210 3730 ;
  END
END xR2_5
