MACRO xc1_1
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc1_1 0 0 ;
  SIZE 24100 BY 19100 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 11450 0 12650 19100 ;
      LAYER M5 ;
        RECT 2500 18670 21600 19100 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 11450 0 12650 19100 ;
      LAYER M5 ;
        RECT 2500 0 21600 430 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 8370 21600 10730 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 22440 0 24100 19100 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 11570 21600 19100 ;
    LAYER M8 ;
      RECT 2500 0 21600 7530 ;
    LAYER M8 ;
      RECT 21600 17440 24100 19100 ;
    LAYER M8 ;
      RECT 21600 0 24100 1660 ;
    LAYER M8 ;
      RECT 22440 0 24100 19100 ;
    LAYER M8 ;
      RECT 0 8370 21600 10730 ;
    LAYER M8 ;
      RECT 5000 10730 6740 16600 ;
    LAYER M8 ;
      RECT 5000 10730 6740 16600 ;
    LAYER M8 ;
      RECT 5000 2500 6740 8370 ;
    LAYER M8 ;
      RECT 8090 10730 9830 16600 ;
    LAYER M8 ;
      RECT 8090 10730 9830 16600 ;
    LAYER M8 ;
      RECT 8090 2500 9830 8370 ;
    LAYER M8 ;
      RECT 11180 10730 12920 16600 ;
    LAYER M8 ;
      RECT 11180 10730 12920 16600 ;
    LAYER M8 ;
      RECT 11180 2500 12920 8370 ;
    LAYER M8 ;
      RECT 14270 10730 16010 16600 ;
    LAYER M8 ;
      RECT 14270 10730 16010 16600 ;
    LAYER M8 ;
      RECT 14270 2500 16010 8370 ;
    LAYER M8 ;
      RECT 17360 10730 19100 16600 ;
    LAYER M8 ;
      RECT 17360 10730 19100 16600 ;
    LAYER M8 ;
      RECT 17360 2500 19100 8370 ;
    LAYER M5 ;
      RECT 11450 0 12650 19100 ;
    LAYER M5 ;
      RECT 2500 8950 21600 10150 ;
    LAYER M5 ;
      RECT 13250 11350 14450 19100 ;
    LAYER M5 ;
      RECT 13250 10750 21600 11950 ;
    LAYER M5 ;
      RECT 15050 13150 16250 19100 ;
    LAYER M5 ;
      RECT 15050 12550 21600 13750 ;
    LAYER M5 ;
      RECT 16850 14950 18050 19100 ;
    LAYER M5 ;
      RECT 16850 14350 21600 15550 ;
    LAYER M5 ;
      RECT 18650 16750 19850 19100 ;
    LAYER M5 ;
      RECT 18650 16150 21600 17350 ;
    LAYER M5 ;
      RECT 20450 18550 21600 19100 ;
    LAYER M5 ;
      RECT 20450 17950 21600 19100 ;
    LAYER M5 ;
      RECT 9650 11350 10850 19100 ;
    LAYER M5 ;
      RECT 2500 10750 10850 11950 ;
    LAYER M5 ;
      RECT 7850 13150 9050 19100 ;
    LAYER M5 ;
      RECT 2500 12550 9050 13750 ;
    LAYER M5 ;
      RECT 6050 14950 7250 19100 ;
    LAYER M5 ;
      RECT 2500 14350 7250 15550 ;
    LAYER M5 ;
      RECT 4250 16750 5450 19100 ;
    LAYER M5 ;
      RECT 2500 16150 5450 17350 ;
    LAYER M5 ;
      RECT 2500 18550 3650 19100 ;
    LAYER M5 ;
      RECT 2500 17950 3650 19100 ;
    LAYER M5 ;
      RECT 9650 0 10850 7750 ;
    LAYER M5 ;
      RECT 2500 7150 10850 8350 ;
    LAYER M5 ;
      RECT 7850 0 9050 5950 ;
    LAYER M5 ;
      RECT 2500 5350 9050 6550 ;
    LAYER M5 ;
      RECT 6050 0 7250 4150 ;
    LAYER M5 ;
      RECT 2500 3550 7250 4750 ;
    LAYER M5 ;
      RECT 4250 0 5450 2350 ;
    LAYER M5 ;
      RECT 2500 1750 5450 2950 ;
    LAYER M5 ;
      RECT 2500 0 3650 550 ;
    LAYER M5 ;
      RECT 2500 0 3650 1150 ;
    LAYER M5 ;
      RECT 13250 0 14450 7750 ;
    LAYER M5 ;
      RECT 13250 7150 21600 8350 ;
    LAYER M5 ;
      RECT 15050 0 16250 5950 ;
    LAYER M5 ;
      RECT 15050 5350 21600 6550 ;
    LAYER M5 ;
      RECT 16850 0 18050 4150 ;
    LAYER M5 ;
      RECT 16850 3550 21600 4750 ;
    LAYER M5 ;
      RECT 18650 0 19850 2350 ;
    LAYER M5 ;
      RECT 18650 1750 21600 2950 ;
    LAYER M5 ;
      RECT 20450 0 21600 550 ;
    LAYER M5 ;
      RECT 20450 0 21600 1150 ;
    LAYER M5 ;
      RECT 2500 18670 21600 19100 ;
    LAYER M5 ;
      RECT 2500 0 21600 430 ;
    LAYER M6 ;
      RECT 12350 10450 13550 19100 ;
    LAYER M6 ;
      RECT 12350 9850 21600 11050 ;
    LAYER M6 ;
      RECT 14150 12250 15350 19100 ;
    LAYER M6 ;
      RECT 14150 11650 21600 12850 ;
    LAYER M6 ;
      RECT 15950 14050 17150 19100 ;
    LAYER M6 ;
      RECT 15950 13450 21600 14650 ;
    LAYER M6 ;
      RECT 17750 15850 18950 19100 ;
    LAYER M6 ;
      RECT 17750 15250 21600 16450 ;
    LAYER M6 ;
      RECT 19550 17650 20750 19100 ;
    LAYER M6 ;
      RECT 19550 17050 21600 18250 ;
    LAYER M6 ;
      RECT 10550 10450 11750 19100 ;
    LAYER M6 ;
      RECT 2500 9850 11750 11050 ;
    LAYER M6 ;
      RECT 8750 12250 9950 19100 ;
    LAYER M6 ;
      RECT 2500 11650 9950 12850 ;
    LAYER M6 ;
      RECT 6950 14050 8150 19100 ;
    LAYER M6 ;
      RECT 2500 13450 8150 14650 ;
    LAYER M6 ;
      RECT 5150 15850 6350 19100 ;
    LAYER M6 ;
      RECT 2500 15250 6350 16450 ;
    LAYER M6 ;
      RECT 3350 17650 4550 19100 ;
    LAYER M6 ;
      RECT 2500 17050 4550 18250 ;
    LAYER M6 ;
      RECT 10550 0 11750 8650 ;
    LAYER M6 ;
      RECT 2500 8050 11750 9250 ;
    LAYER M6 ;
      RECT 8750 0 9950 6850 ;
    LAYER M6 ;
      RECT 2500 6250 9950 7450 ;
    LAYER M6 ;
      RECT 6950 0 8150 5050 ;
    LAYER M6 ;
      RECT 2500 4450 8150 5650 ;
    LAYER M6 ;
      RECT 5150 0 6350 3250 ;
    LAYER M6 ;
      RECT 2500 2650 6350 3850 ;
    LAYER M6 ;
      RECT 3350 0 4550 1450 ;
    LAYER M6 ;
      RECT 2500 850 4550 2050 ;
    LAYER M6 ;
      RECT 12350 0 13550 8650 ;
    LAYER M6 ;
      RECT 12350 8050 21600 9250 ;
    LAYER M6 ;
      RECT 14150 0 15350 6850 ;
    LAYER M6 ;
      RECT 14150 6250 21600 7450 ;
    LAYER M6 ;
      RECT 15950 0 17150 5050 ;
    LAYER M6 ;
      RECT 15950 4450 21600 5650 ;
    LAYER M6 ;
      RECT 17750 0 18950 3250 ;
    LAYER M6 ;
      RECT 17750 2650 21600 3850 ;
    LAYER M6 ;
      RECT 19550 0 20750 1450 ;
    LAYER M6 ;
      RECT 19550 850 21600 2050 ;
    LAYER M6 ;
      RECT 2500 18670 21600 19100 ;
    LAYER M6 ;
      RECT 2500 0 21600 430 ;
  END
END xc1_1
