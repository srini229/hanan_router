MACRO xR0_8
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xR0_8 0 0 ;
  SIZE 2280 BY 9320 ;
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 230 235 320 9085 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1960 235 2050 9085 ;
    END
  END MINUS
  OBS
    LAYER PO ;
      RECT 200 220 2080 9100 ;
    LAYER RPO ;
      RECT 540 0 1740 9320 ;
    LAYER M1 ;
      RECT 230 235 320 9085 ;
    LAYER M1 ;
      RECT 1960 235 2050 9085 ;
    LAYER RH ;
      RECT 0 20 2280 9300 ;
  END
END xR0_8
