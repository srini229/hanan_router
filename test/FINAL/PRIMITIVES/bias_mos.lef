MACRO bias_mos
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN bias_mos 0 0 ;
  SIZE 2810 BY 3610 ;
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M3 ;
        RECT 680 915 860 2695 ;
      LAYER M3 ;
        RECT 0 915 720 2695 ;
    END
  END G
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M2 ;
        RECT 2310 935 2810 2675 ;
    END
  END D
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 955 3180 1975 3390 ;
    END
  END B
  OBS
    LAYER M2 ;
      RECT 2310 935 2810 2675 ;
    LAYER M2 ;
      RECT 1950 935 2730 1115 ;
    LAYER M2 ;
      RECT 1950 1455 2730 1635 ;
    LAYER M2 ;
      RECT 1950 1975 2730 2155 ;
    LAYER M2 ;
      RECT 1950 2495 2730 2675 ;
    LAYER M2 ;
      RECT 975 2755 1955 2935 ;
    LAYER M2 ;
      RECT 975 2235 1955 2415 ;
    LAYER M2 ;
      RECT 975 1715 1955 1895 ;
    LAYER M2 ;
      RECT 975 1195 1955 1375 ;
    LAYER M2 ;
      RECT 975 675 1955 855 ;
    LAYER M2 ;
      RECT 680 915 860 2695 ;
    LAYER M2 ;
      RECT 1170 225 1760 425 ;
    LAYER M2 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M2 ;
      RECT 975 675 1955 855 ;
    LAYER M2 ;
      RECT 975 2495 1955 2675 ;
    LAYER M2 ;
      RECT 975 2235 1955 2415 ;
    LAYER M2 ;
      RECT 975 1975 1955 2155 ;
    LAYER M2 ;
      RECT 975 1715 1955 1895 ;
    LAYER M2 ;
      RECT 975 1455 1955 1635 ;
    LAYER M2 ;
      RECT 975 1195 1955 1375 ;
    LAYER M2 ;
      RECT 975 935 1955 1115 ;
    LAYER M2 ;
      RECT 975 2755 1955 2935 ;
    LAYER M2 ;
      RECT 680 915 860 2695 ;
    LAYER M2 ;
      RECT 1170 225 1760 425 ;
    LAYER M2 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M3 ;
      RECT 0 915 720 2695 ;
    LAYER M3 ;
      RECT 975 2755 1955 2935 ;
    LAYER M3 ;
      RECT 975 2235 1955 2415 ;
    LAYER M3 ;
      RECT 975 1715 1955 1895 ;
    LAYER M3 ;
      RECT 975 1195 1955 1375 ;
    LAYER M3 ;
      RECT 975 675 1955 855 ;
    LAYER M3 ;
      RECT 680 915 860 2695 ;
    LAYER M3 ;
      RECT 1170 225 1760 425 ;
    LAYER M3 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M3 ;
      RECT 1175 2755 1755 2935 ;
    LAYER M3 ;
      RECT 1175 2235 1755 2415 ;
    LAYER M3 ;
      RECT 1175 1715 1755 1895 ;
    LAYER M3 ;
      RECT 1175 1195 1755 1375 ;
    LAYER M3 ;
      RECT 1175 675 1755 855 ;
    LAYER M3 ;
      RECT 1170 225 1760 425 ;
    LAYER M3 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M4 ;
      RECT 1175 215 1755 3395 ;
    LAYER M4 ;
      RECT 1175 2755 1755 2935 ;
    LAYER M4 ;
      RECT 1175 2235 1755 2415 ;
    LAYER M4 ;
      RECT 1175 1715 1755 1895 ;
    LAYER M4 ;
      RECT 1175 1195 1755 1375 ;
    LAYER M4 ;
      RECT 1175 675 1755 855 ;
    LAYER M4 ;
      RECT 1170 225 1760 425 ;
    LAYER M4 ;
      RECT 1170 3185 1760 3385 ;
    LAYER PO ;
      RECT 675 865 865 2745 ;
    LAYER PO ;
      RECT 1965 2685 2105 2745 ;
    LAYER PO ;
      RECT 865 2685 965 2745 ;
    LAYER PO ;
      RECT 1965 2425 2105 2485 ;
    LAYER PO ;
      RECT 865 2425 965 2485 ;
    LAYER PO ;
      RECT 1965 2165 2105 2225 ;
    LAYER PO ;
      RECT 865 2165 965 2225 ;
    LAYER PO ;
      RECT 1965 1905 2105 1965 ;
    LAYER PO ;
      RECT 865 1905 965 1965 ;
    LAYER PO ;
      RECT 1965 1645 2105 1705 ;
    LAYER PO ;
      RECT 865 1645 965 1705 ;
    LAYER PO ;
      RECT 1965 1385 2105 1445 ;
    LAYER PO ;
      RECT 865 1385 965 1445 ;
    LAYER PO ;
      RECT 1965 1125 2105 1185 ;
    LAYER PO ;
      RECT 865 1125 965 1185 ;
    LAYER PO ;
      RECT 1965 865 2105 925 ;
    LAYER PO ;
      RECT 865 865 965 925 ;
    LAYER PO ;
      RECT 965 865 1965 925 ;
    LAYER PO ;
      RECT 965 1125 1965 1185 ;
    LAYER PO ;
      RECT 965 1385 1965 1445 ;
    LAYER PO ;
      RECT 965 1645 1965 1705 ;
    LAYER PO ;
      RECT 965 1905 1965 1965 ;
    LAYER PO ;
      RECT 965 2165 1965 2225 ;
    LAYER PO ;
      RECT 965 2425 1965 2485 ;
    LAYER PO ;
      RECT 965 2685 1965 2745 ;
    LAYER M1 ;
      RECT 955 2540 1975 2630 ;
    LAYER M1 ;
      RECT 955 2280 1975 2370 ;
    LAYER M1 ;
      RECT 955 2020 1975 2110 ;
    LAYER M1 ;
      RECT 955 1760 1975 1850 ;
    LAYER M1 ;
      RECT 955 1500 1975 1590 ;
    LAYER M1 ;
      RECT 955 1240 1975 1330 ;
    LAYER M1 ;
      RECT 955 980 1975 1070 ;
    LAYER M1 ;
      RECT 955 720 1975 810 ;
    LAYER M1 ;
      RECT 955 2800 1975 2890 ;
    LAYER M1 ;
      RECT 975 675 1955 855 ;
    LAYER M1 ;
      RECT 975 2495 1955 2675 ;
    LAYER M1 ;
      RECT 975 2235 1955 2415 ;
    LAYER M1 ;
      RECT 975 1975 1955 2155 ;
    LAYER M1 ;
      RECT 975 1715 1955 1895 ;
    LAYER M1 ;
      RECT 975 1455 1955 1635 ;
    LAYER M1 ;
      RECT 975 1195 1955 1375 ;
    LAYER M1 ;
      RECT 975 935 1955 1115 ;
    LAYER M1 ;
      RECT 975 2755 1955 2935 ;
    LAYER M1 ;
      RECT 680 915 860 2695 ;
    LAYER M1 ;
      RECT 1170 225 1760 425 ;
    LAYER M1 ;
      RECT 1170 3185 1760 3385 ;
    LAYER M1 ;
      RECT 1975 220 2405 430 ;
    LAYER M1 ;
      RECT 1975 3180 2405 3390 ;
    LAYER M1 ;
      RECT 525 3180 955 3390 ;
    LAYER M1 ;
      RECT 525 220 955 430 ;
    LAYER M1 ;
      RECT 2405 220 2625 3390 ;
    LAYER M1 ;
      RECT 305 220 525 3390 ;
    LAYER M1 ;
      RECT 725 865 815 2745 ;
    LAYER M1 ;
      RECT 955 220 1975 430 ;
    LAYER M1 ;
      RECT 955 3180 1975 3390 ;
  END
END bias_mos
