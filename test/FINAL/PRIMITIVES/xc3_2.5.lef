MACRO xc3_2.5
  UNITS
    DATABASE MICRONS UNITS 1000;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN xc3_2.5 0 0 ;
  SIZE 18360 BY 28110 ;
  PIN BULK1
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 2500 27680 15860 28110 ;
      LAYER M5 ;
        RECT 8580 0 9780 28110 ;
    END
  END BULK1
  PIN BULK2
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M5 ;
        RECT 2500 0 15860 430 ;
      LAYER M5 ;
        RECT 8580 0 9780 28110 ;
    END
  END BULK2
  PIN PLUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 0 12875 15860 15235 ;
    END
  END PLUS
  PIN MINUS
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M8 ;
        RECT 16700 0 18360 28110 ;
    END
  END MINUS
  OBS
    LAYER M8 ;
      RECT 2500 16075 15860 28110 ;
    LAYER M8 ;
      RECT 2500 0 15860 12035 ;
    LAYER M8 ;
      RECT 15860 26450 18360 28110 ;
    LAYER M8 ;
      RECT 15860 0 18360 1660 ;
    LAYER M8 ;
      RECT 16700 0 18360 28110 ;
    LAYER M8 ;
      RECT 0 12875 15860 15235 ;
    LAYER M8 ;
      RECT 5000 15235 6740 25610 ;
    LAYER M8 ;
      RECT 5000 15235 6740 25610 ;
    LAYER M8 ;
      RECT 5000 2500 6740 12875 ;
    LAYER M8 ;
      RECT 8310 15235 10050 25610 ;
    LAYER M8 ;
      RECT 8310 15235 10050 25610 ;
    LAYER M8 ;
      RECT 8310 2500 10050 12875 ;
    LAYER M8 ;
      RECT 11620 15235 13360 25610 ;
    LAYER M8 ;
      RECT 11620 15235 13360 25610 ;
    LAYER M8 ;
      RECT 11620 2500 13360 12875 ;
    LAYER M5 ;
      RECT 8580 0 9780 28110 ;
    LAYER M5 ;
      RECT 2500 13455 15860 14655 ;
    LAYER M5 ;
      RECT 10380 15855 11580 28110 ;
    LAYER M5 ;
      RECT 10380 15255 15860 16455 ;
    LAYER M5 ;
      RECT 12180 17655 13380 28110 ;
    LAYER M5 ;
      RECT 12180 17055 15860 18255 ;
    LAYER M5 ;
      RECT 13980 19455 15180 28110 ;
    LAYER M5 ;
      RECT 13980 18855 15860 20055 ;
    LAYER M5 ;
      RECT 15780 21255 15860 28110 ;
    LAYER M5 ;
      RECT 15780 20655 15860 21855 ;
    LAYER M5 ;
      RECT 6780 15855 7980 28110 ;
    LAYER M5 ;
      RECT 2500 15255 7980 16455 ;
    LAYER M5 ;
      RECT 4980 17655 6180 28110 ;
    LAYER M5 ;
      RECT 2500 17055 6180 18255 ;
    LAYER M5 ;
      RECT 3180 19455 4380 28110 ;
    LAYER M5 ;
      RECT 2500 18855 4380 20055 ;
    LAYER M5 ;
      RECT 2500 21255 2580 28110 ;
    LAYER M5 ;
      RECT 2500 20655 2580 21855 ;
    LAYER M5 ;
      RECT 6780 0 7980 12255 ;
    LAYER M5 ;
      RECT 2500 11655 7980 12855 ;
    LAYER M5 ;
      RECT 4980 0 6180 10455 ;
    LAYER M5 ;
      RECT 2500 9855 6180 11055 ;
    LAYER M5 ;
      RECT 3180 0 4380 8655 ;
    LAYER M5 ;
      RECT 2500 8055 4380 9255 ;
    LAYER M5 ;
      RECT 2500 0 2580 6855 ;
    LAYER M5 ;
      RECT 2500 6255 2580 7455 ;
    LAYER M5 ;
      RECT 10380 0 11580 12255 ;
    LAYER M5 ;
      RECT 10380 11655 15860 12855 ;
    LAYER M5 ;
      RECT 12180 0 13380 10455 ;
    LAYER M5 ;
      RECT 12180 9855 15860 11055 ;
    LAYER M5 ;
      RECT 13980 0 15180 8655 ;
    LAYER M5 ;
      RECT 13980 8055 15860 9255 ;
    LAYER M5 ;
      RECT 15780 0 15860 6855 ;
    LAYER M5 ;
      RECT 15780 6255 15860 7455 ;
    LAYER M5 ;
      RECT 2500 27680 15860 28110 ;
    LAYER M5 ;
      RECT 2500 0 15860 430 ;
    LAYER M6 ;
      RECT 9480 14955 10680 28110 ;
    LAYER M6 ;
      RECT 9480 14355 15860 15555 ;
    LAYER M6 ;
      RECT 11280 16755 12480 28110 ;
    LAYER M6 ;
      RECT 11280 16155 15860 17355 ;
    LAYER M6 ;
      RECT 13080 18555 14280 28110 ;
    LAYER M6 ;
      RECT 13080 17955 15860 19155 ;
    LAYER M6 ;
      RECT 14880 20355 15860 28110 ;
    LAYER M6 ;
      RECT 14880 19755 15860 20955 ;
    LAYER M6 ;
      RECT 7680 14955 8880 28110 ;
    LAYER M6 ;
      RECT 2500 14355 8880 15555 ;
    LAYER M6 ;
      RECT 5880 16755 7080 28110 ;
    LAYER M6 ;
      RECT 2500 16155 7080 17355 ;
    LAYER M6 ;
      RECT 4080 18555 5280 28110 ;
    LAYER M6 ;
      RECT 2500 17955 5280 19155 ;
    LAYER M6 ;
      RECT 2500 20355 3480 28110 ;
    LAYER M6 ;
      RECT 2500 19755 3480 20955 ;
    LAYER M6 ;
      RECT 7680 0 8880 13155 ;
    LAYER M6 ;
      RECT 2500 12555 8880 13755 ;
    LAYER M6 ;
      RECT 5880 0 7080 11355 ;
    LAYER M6 ;
      RECT 2500 10755 7080 11955 ;
    LAYER M6 ;
      RECT 4080 0 5280 9555 ;
    LAYER M6 ;
      RECT 2500 8955 5280 10155 ;
    LAYER M6 ;
      RECT 2500 0 3480 7755 ;
    LAYER M6 ;
      RECT 2500 7155 3480 8355 ;
    LAYER M6 ;
      RECT 9480 0 10680 13155 ;
    LAYER M6 ;
      RECT 9480 12555 15860 13755 ;
    LAYER M6 ;
      RECT 11280 0 12480 11355 ;
    LAYER M6 ;
      RECT 11280 10755 15860 11955 ;
    LAYER M6 ;
      RECT 13080 0 14280 9555 ;
    LAYER M6 ;
      RECT 13080 8955 15860 10155 ;
    LAYER M6 ;
      RECT 14880 0 15860 7755 ;
    LAYER M6 ;
      RECT 14880 7155 15860 8355 ;
    LAYER M6 ;
      RECT 2500 27680 15860 28110 ;
    LAYER M6 ;
      RECT 2500 0 15860 430 ;
  END
END xc3_2.5
