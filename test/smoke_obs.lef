MACRO BLOCK_A
  UNITS 
    DATABASE MICRONS UNITS 1;
  END UNITS 
  ORIGIN 0 0 ;
  FOREIGN BLOCK_A 0 0 ;
  SIZE 200 BY 200 ;
  PIN A
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 32 32 ;
    END
  END A
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 120 120 152 152 ;
    END
  END B
  OBS
    LAYER M2 ;
      RECT 60 60 90 90 ;
  END
END BLOCK_A
