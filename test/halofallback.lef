MACRO NFET_W1_L0P3_X1_Y1
  UNITS 
    DATABASE MICRONS UNITS 1000;
  END UNITS 
  ORIGIN 0 0 ;
  FOREIGN NFET_W1_L0P3_X1_Y1 0 0 ;
  SIZE 2380 BY 2870 ;
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 990 95 1390 325 ;
    END
  END B
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1340 920 1730 1610 ;
    END
  END D
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 960 2015 1420 2245 ;
    END
  END G
  PIN S
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 650 920 1040 1610 ;
    END
  END S
  OBS
    LAYER li1 ;
      RECT 125 125 2255 2745 ;
    LAYER li1 ;
      RECT 805 920 975 1610 ;
    LAYER li1 ;
      RECT 1405 920 1575 1610 ;
    LAYER li1 ;
      RECT 1025 2045 1355 2215 ;
  END
END NFET_W1_L0P3_X1_Y1

MACRO NFET_W1_L0P3_X2_Y1
  UNITS 
    DATABASE MICRONS UNITS 1000;
  END UNITS 
  ORIGIN 0 0 ;
  FOREIGN NFET_W1_L0P3_X2_Y1 0 0 ;
  SIZE 3170 BY 2870 ;
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1380 95 1790 325 ;
    END
  END B
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1390 1340 1780 1610 ;
    END
  END D
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 960 2015 2210 2245 ;
    END
  END G
  PIN S
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 740 920 2430 1190 ;
    END
  END S
  OBS
    LAYER li1 ;
      RECT 125 125 3045 2745 ;
    LAYER li1 ;
      RECT 805 920 975 1610 ;
    LAYER li1 ;
      RECT 2195 920 2365 1610 ;
    LAYER li1 ;
      RECT 1500 920 1670 1610 ;
    LAYER li1 ;
      RECT 1025 2045 1355 2215 ;
    LAYER li1 ;
      RECT 1815 2045 2145 2215 ;
  END
END NFET_W1_L0P3_X2_Y1

MACRO PFET_W1_L0P2_X1_Y1
  UNITS 
    DATABASE MICRONS UNITS 1000;
  END UNITS 
  ORIGIN 0 0 ;
  FOREIGN PFET_W1_L0P2_X1_Y1 0 0 ;
  SIZE 2660 BY 3250 ;
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1130 285 1530 515 ;
    END
  END B
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1430 1110 1820 1800 ;
    END
  END D
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1100 2205 1560 2435 ;
    END
  END G
  PIN S
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 840 1110 1230 1800 ;
    END
  END S
  OBS
    LAYER li1 ;
      RECT 315 315 2345 2935 ;
    LAYER li1 ;
      RECT 995 1110 1165 1800 ;
    LAYER li1 ;
      RECT 1495 1110 1665 1800 ;
    LAYER li1 ;
      RECT 1165 2235 1495 2405 ;
  END
END PFET_W1_L0P2_X1_Y1
