MACRO NARROW_ESCAPE_A
  UNITS
    DATABASE MICRONS UNITS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN NARROW_ESCAPE_A 0 0 ;
  SIZE 80 BY 200 ;
  PIN A
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 8 32 ;
    END
  END A
  OBS
    LAYER M1 ;
      RECT 36 0 80 200 ;
  END
END NARROW_ESCAPE_A
