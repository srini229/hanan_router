MACRO PINCELL
  UNITS
    DATABASE MICRONS UNITS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN PINCELL 0 0 ;
  SIZE 32 BY 32 ;
  PIN P
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 32 32 ;
    END
  END P
END PINCELL
MACRO NOPORT
  UNITS
    DATABASE MICRONS UNITS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN NOPORT 0 0 ;
  SIZE 32 BY 32 ;
  PIN P
    DIRECTION INOUT ;
    USE SIGNAL ;
  END P
END NOPORT
