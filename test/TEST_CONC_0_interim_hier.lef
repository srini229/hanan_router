MACRO TEST_CONC_0
  UNITS
    DISTANCE MICRONS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN TEST_CONC_0 0 0 ;
  SIZE 1000 BY 1000 ;
  PIN C
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 36 72 ;
        RECT 964 60 996 972 ;
        RECT 964 40 996 112 ;
        RECT 2000 0 2036 72 ;
        RECT 2964 40 2996 972 ;
      LAYER M2 ;
        RECT -16 20 56 52 ;
        RECT 0 20 36 52 ;
        RECT -20 20 52 52 ;
        RECT -16 60 1984 92 ;
        RECT 1980 20 2056 52 ;
        RECT 1984 60 3016 92 ;
      LAYER M3 ;
        RECT -4 -4 40 76 ;
        RECT 0 40 40 112 ;
        RECT 1996 -4 2040 76 ;
        RECT 2000 40 2040 112 ;
      LAYER M4 ;
        RECT -24 16 56 56 ;
        RECT -4 16 40 56 ;
        RECT -20 16 60 56 ;
        RECT 1976 16 2060 56 ;
      LAYER V1 ;
        RECT 4 20 36 52 ;
        RECT 964 60 996 92 ;
        RECT 2004 20 2036 52 ;
        RECT 2964 60 2996 92 ;
      LAYER V2 ;
        RECT 0 20 32 52 ;
        RECT 4 60 36 92 ;
        RECT 2000 20 2032 52 ;
        RECT 2004 60 2036 92 ;
      LAYER V3 ;
        RECT -4 16 36 56 ;
        RECT 0 16 40 56 ;
        RECT 1996 16 2040 56 ;
    END
  END C
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 2900 800 2936 872 ;
        RECT 2064 100 2096 812 ;
        RECT 2064 760 2096 832 ;
        RECT 900 800 936 872 ;
        RECT 64 100 96 832 ;
      LAYER M2 ;
        RECT 2884 820 2956 852 ;
        RECT 2900 820 2936 852 ;
        RECT 2880 820 2952 852 ;
        RECT 952 780 2952 812 ;
        RECT 880 820 956 852 ;
        RECT 44 780 952 812 ;
      LAYER M3 ;
        RECT 2896 796 2940 876 ;
        RECT 2896 760 2936 832 ;
        RECT 896 796 940 876 ;
        RECT 896 760 936 832 ;
      LAYER M4 ;
        RECT 2876 816 2956 856 ;
        RECT 2896 816 2940 856 ;
        RECT 2880 816 2960 856 ;
        RECT 876 816 960 856 ;
      LAYER V1 ;
        RECT 2904 820 2936 852 ;
        RECT 2064 780 2096 812 ;
        RECT 904 820 936 852 ;
        RECT 64 780 96 812 ;
      LAYER V2 ;
        RECT 2900 820 2932 852 ;
        RECT 2900 780 2932 812 ;
        RECT 900 820 932 852 ;
        RECT 900 780 932 812 ;
      LAYER V3 ;
        RECT 2896 816 2936 856 ;
        RECT 2900 816 2940 856 ;
        RECT 896 816 940 856 ;
    END
  END D
END TEST_CONC_0
