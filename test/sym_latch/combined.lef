MACRO NFET_W1_L0P3_X2_Y1
  UNITS 
    DATABASE MICRONS UNITS 1000;
  END UNITS 
  ORIGIN 0 0 ;
  FOREIGN NFET_W1_L0P3_X2_Y1 0 0 ;
  SIZE 3170 BY 2870 ;
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1380 95 1790 325 ;
    END
  END B
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1390 1340 1780 1610 ;
    END
  END D
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 960 2015 2210 2245 ;
    END
  END G
  PIN S
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 740 920 2430 1190 ;
    END
  END S
  OBS
    LAYER li1 ;
      RECT 125 125 3045 2745 ;
    LAYER li1 ;
      RECT 805 920 975 1610 ;
    LAYER li1 ;
      RECT 2195 920 2365 1610 ;
    LAYER li1 ;
      RECT 1500 920 1670 1610 ;
    LAYER li1 ;
      RECT 1025 2045 1355 2215 ;
    LAYER li1 ;
      RECT 1815 2045 2145 2215 ;
  END
END NFET_W1_L0P3_X2_Y1

MACRO NFET_W2_L0P3_X4_Y1
  UNITS 
    DATABASE MICRONS UNITS 1000;
  END UNITS 
  ORIGIN 0 0 ;
  FOREIGN NFET_W2_L0P3_X4_Y1 0 0 ;
  SIZE 4750 BY 3870 ;
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 2170 95 2580 325 ;
    END
  END B
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1440 1840 3310 2650 ;
    END
  END D
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 960 3015 3790 3245 ;
    END
  END G
  PIN S
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 740 880 4010 1690 ;
    END
  END S
  OBS
    LAYER li1 ;
      RECT 125 125 4625 3745 ;
    LAYER li1 ;
      RECT 805 880 975 2650 ;
    LAYER li1 ;
      RECT 3775 880 3945 2650 ;
    LAYER li1 ;
      RECT 1500 880 1670 2650 ;
    LAYER li1 ;
      RECT 2290 880 2460 2650 ;
    LAYER li1 ;
      RECT 3080 880 3250 2650 ;
    LAYER li1 ;
      RECT 1025 3045 1355 3215 ;
    LAYER li1 ;
      RECT 2605 3045 2935 3215 ;
    LAYER li1 ;
      RECT 1815 3045 2145 3215 ;
    LAYER li1 ;
      RECT 3395 3045 3725 3215 ;
  END
END NFET_W2_L0P3_X4_Y1

MACRO PFET_W1_L0P2_X2_Y1
  UNITS 
    DATABASE MICRONS UNITS 1000;
  END UNITS 
  ORIGIN 0 0 ;
  FOREIGN PFET_W1_L0P2_X2_Y1 0 0 ;
  SIZE 3350 BY 3250 ;
  PIN B
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1470 285 1880 515 ;
    END
  END B
  PIN D
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1480 1530 1870 1800 ;
    END
  END D
  PIN G
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 1100 2205 2250 2435 ;
    END
  END G
  PIN S
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 930 1110 2420 1380 ;
    END
  END S
  OBS
    LAYER li1 ;
      RECT 315 315 3035 2935 ;
    LAYER li1 ;
      RECT 995 1110 1165 1800 ;
    LAYER li1 ;
      RECT 2185 1110 2355 1800 ;
    LAYER li1 ;
      RECT 1590 1110 1760 1800 ;
    LAYER li1 ;
      RECT 1165 2235 1495 2405 ;
    LAYER li1 ;
      RECT 1855 2235 2185 2405 ;
  END
END PFET_W1_L0P2_X2_Y1
