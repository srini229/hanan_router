MACRO PINCELL
  UNITS
    DATABASE MICRONS UNITS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN PINCELL 0 0 ;
  SIZE 32 BY 32 ;
  PIN P
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 32 32 ;
    END
  END P
END PINCELL
MACRO WIDEPIN
  UNITS
    DATABASE MICRONS UNITS 1;
  END UNITS
  ORIGIN 0 0 ;
  FOREIGN WIDEPIN 0 0 ;
  SIZE 120 BY 32 ;
  PIN P
    DIRECTION INOUT ;
    USE SIGNAL ;
    PORT
      LAYER M1 ;
        RECT 0 0 120 32 ;
    END
  END P
END WIDEPIN
